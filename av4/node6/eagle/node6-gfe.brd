File: av4/node6/eagle/node6-gfe.brd (EAGLE design)
At the start: 100 x 80 mm, 50 parts, among them J13 PGOOD Jumper, J15 Auxiliary Header, J2 ROCKETNET-CONNECTOR-16M, J3 MICROSD-7T-DET504077, Q2000 PMV45EN, Q2001 Si7309DN, Q2002 PMV45EN, U1 DP83630/LLP, U2 STM32F407V_NODE6/LQFP100, U2000 MAX5902AAEUT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

Commit message: node6: new regulator library, added ltc3586, primary switcher output +5
moving toward ltc3586 as main switching chip to generate 3.3 and 5, buck
regulators available to generate other supplies if needed in other
projects.
Parts:
- removed J13: PGOOD Jumper, headers:1.27MM_2X1
- removed R128: 750, rcl_custom:0402-B-NOSILK
- added U3: LTC3586, regulator:QFN40P600X400X75-39N
- R73: value 154k -> 93.1k
- moved U5 84.9 mm to (17.0, 31.0)
Connections:
- removed net +3V3: C104.1, R128.1, U5.VOUT@1, U5.VOUT@10, U5.VOUT@11, U5.VOUT@12, U5.VOUT@2, U5.VOUT@3, U5.VOUT@4, U5.VOUT@5, U5.VOUT@6, U5.VOUT@7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
- removed net N$29: J13.2, LED22.A, U5.PGOOD
- removed net N$30: J13.1, R128.2
- new net +5V_RAW: C104.1, U3.35, U3.36, U5.VOUT@1, U5.VOUT@10, U5.VOUT@11, U5.VOUT@12, U5.VOUT@2, U5.VOUT@3, U5.VOUT@4, U5.VOUT@5, U5.VOUT@6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
- new net PGOOD_5V: LED22.A, U5.PGOOD
- net GND: now also U3.39
