File: av4/rocketnet-hub/eagle/mcu_page_combined_routed.brd (EAGLE design)
At the start: 112.7 x 76.2 mm, 449 parts, among them J1 ROCKETNET-CONNECTOR-16M, J10 UART Header, J11 I2C Header, J12 BOOT1 Jumper, J13 PGOOD Jumper, J14 ROCKETNET-UMBILICAL-18, J15 Auxiliary Header, J16 Auxiliary Header, J17 Auxiliary Header, J18 Auxiliary Header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

Commit message: Latest patches on the RNH: added connections for port 8, added proposed umbilical disconect patch. Still to do: vbat, and a checklist to make sure we have both RNHs up to the same patch level.
Parts:
- added C58: 100n, rcl_custom:0402-B-NOSILK
- added R31: 100, rcl_custom:0402-B-NOSILK
- LED37: value RGB -> (none)
- R44: value 750 -> 110
- R45: value 750 -> 400
- R49, R52, R54, R56, R58, R60, R62: value TBD -> 69.8k
Connections:
- new net N$3: C58.1, R31.2, U1.7
- new net UMB-DETECT: J14.RR@10, R31.1
- net GND: now also C58.2
- net LED5-3: no longer U1.43
- net ROCKET_RDY: no longer J14.RR@10
Routing:
- net ROCKET_RDY: track 14.1 -> 12.9 mm
Changed lines of the file:
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@@
 <layer number="98" name="Guide" color="6" fill="1" visible="no" active="no"/>
 <layer number="100" name="Muster" color="7" fill="1" visible="no" active="no"/>
-<layer number="101" name="Patch_Top" color="11" fill="1" visible="yes" active="yes"/>
+<layer number="101" name="Patch_Top" color="11" fill="1" visible="no" active="yes"/>
 <layer number="116" name="Patch_BOT" color="7" fill="1" visible="no" active="yes"/>
 <layer number="200" name="200bmp" color="1" fill="10" visible="no" active="no"/>
@@
 <attribute name="VALUE" x="96.939" y="16.438" size="1" layer="28" ratio="10" rot="MR0"/>
 </element>
-<element name="LED37" library="LED_RGB_PLCC6" package="PLCC-6" value="RGB" x="64.389" y="52.07" smashed="yes" rot="R180">
+<element name="LED37" library="LED_RGB_PLCC6" package="PLCC-6" value="" x="64.389" y="52.07" smashed="yes" rot="R180">
 <attribute name="NAME" x="68.413" y="49.843" size="0.762" layer="25" ratio="20" rot="R180"/>
 <attribute name="VALUE" x="66.889" y="55.07" size="1" layer="27" rot="R180"/>
 </element>
-<element name="R44" library="rcl_custom" package="0402-B-NOSILK" value="750" x="63.246" y="55.118" smashed="yes" rot="R90">
+<element name="R44" library="rcl_custom" package="0402-B-NOSILK" value="110" x="63.246" y="55.118" smashed="yes" rot="R90">
 <attribute name="NAME" x="62.948" y="58.344" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="65.096" y="54.318" size="1" layer="27" ratio="10" rot="R90"/>
 </element>
-<element name="R45" library="rcl_custom" package="0402-B-NOSILK" value="750" x="65.532" y="55.118" smashed="yes" rot="R90">
+<element name="R45" library="rcl_custom" package="0402-B-NOSILK" value="400" x="65.532" y="55.118" smashed="yes" rot="R90">
 <attribute name="NAME" x="65.271" y="58.471" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="67.382" y="54.318" size="1" layer="27" ratio="10" rot="R90"/>
@@
 <attribute name="VALUE" x="48.406540625" y="29.622165625" size="1" layer="28" ratio="10" rot="MR45"/>
 </element>
-<element name="R49" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="97.155" y="63.373" smashed="yes" rot="R90">
+<element name="R49" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="97.155" y="63.373" smashed="yes" rot="R90">
 <attribute name="NAME" x="96.974" y="62.197" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="99.005" y="62.573" size="1" layer="27" ratio="10" rot="R90"/>
@@
 <attribute name="VALUE" x="100.275" y="62.573" size="1" layer="27" ratio="10" rot="R90"/>
 </element>
-<element name="R52" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="73.914" y="63.373" smashed="yes" rot="R90">
+<element name="R52" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="73.914" y="63.373" smashed="yes" rot="R90">
 <attribute name="NAME" x="73.6158" y="62.451" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="75.764" y="62.573" size="1" layer="27" ratio="10" rot="R90"/>
 </element>
-<element name="R54" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="51.054" y="63.373" smashed="yes" rot="R90">
+<element name="R54" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="51.054" y="63.373" smashed="yes" rot="R90">
 <attribute name="NAME" x="50.8704" y="62.451" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="52.904" y="62.573" size="1" layer="27" ratio="10" rot="R90"/>
 </element>
-<element name="R56" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="82.804" y="13.208" smashed="yes" rot="R270">
+<element name="R56" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="82.804" y="13.208" smashed="yes" rot="R270">
 <attribute name="NAME" x="82.461" y="16.421" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="80.954" y="14.008" size="1" layer="27" ratio="10" rot="R270"/>
 </element>
-<element name="R58" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="28.194" y="63.373" smashed="yes" rot="R90">
+<element name="R58" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="28.194" y="63.373" smashed="yes" rot="R90">
 <attribute name="NAME" x="27.871" y="62.324" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="30.044" y="62.573" size="1" layer="27" ratio="10" rot="R90"/>
 </element>
-<element name="R60" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="36.83" y="13.208" smashed="yes" rot="R270">
+<element name="R60" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="36.83" y="13.208" smashed="yes" rot="R270">
 <attribute name="NAME" x="36.487" y="16.802" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="34.98" y="14.008" size="1" layer="27" ratio="10" rot="R270"/>
 </element>
-<element name="R62" library="rcl_custom" package="0402-B-NOSILK" value="TBD" x="59.817" y="13.208" smashed="yes" rot="R270">
+<element name="R62" library="rcl_custom" package="0402-B-NOSILK" value="69.8k" x="59.817" y="13.208" smashed="yes" rot="R270">
 <attribute name="NAME" x="59.474" y="16.548" size="0.762" layer="25" ratio="20" rot="R270"/>
 <attribute name="VALUE" x="57.967" y="14.008" size="1" layer="27" ratio="10" rot="R270"/>
@@
 <attribute name="VALUE" x="53.285" y="45.25" size="1" layer="28" ratio="10" rot="MR270"/>
 </element>
+<element name="R31" library="rcl_custom" package="0402-B-NOSILK" value="100" x="23.241" y="-2.667"/>
+<element name="C58" library="rcl_custom" package="0402-B-NOSILK" value="100n" x="23.114" y="-1.016" rot="R90"/>
 </elements>
 <signals>
@@
 <wire x1="58.67884375" y1="35.823115625" x2="59.309" y2="35.192959375" width="0.1778" layer="1"/>
 <wire x1="59.309" y1="35.192959375" x2="59.309" y2="34.925" width="0.1778" layer="1"/>
+<contactref element="C58" pad="2"/>
+<wire x1="20.574" y1="0.889" x2="23.114" y2="-0.536" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="+3V3" class="1">
@@
 <wire x1="57.912" y1="15.24" x2="68.199" y2="25.527" width="0.1778" layer="14"/>
 <wire x1="28.321" y1="8.89" x2="27.293" y2="8.89" width="0.1778" layer="1"/>
-<contactref element="U1" pad="43"/>
-<wire x1="68.199" y1="25.527" x2="57.26463125" y2="34.4089" width="0" layer="19" extent="1-14"/>
 </signal>
 <signal name="LED6-3">
@@
 </signal>
 <signal name="ROCKET_RDY">
-<contactref element="J14" pad="RR@10"/>
 <contactref element="J14" pad="RR@9"/>
 <contactref element="R167" pad="2"/>
-<wire x1="20.3" y1="3.685" x2="20.3" y2="4.955" width="0.254" layer="16"/>
 <wire x1="20.3" y1="4.955" x2="20.3" y2="12.045" width="0.254" layer="1"/>
 <wire x1="20.3" y1="12.045" x2="20.701" y2="12.446" width="0.254" layer="1"/>
@@
 <wire x1="51.435" y1="45.72" x2="51.435" y2="44.93" width="0.1778" layer="16"/>
 </signal>
+<signal name="UMB-DETECT">
+<contactref element="J14" pad="RR@10"/>
+<contactref element="R31" pad="1"/>
+<wire x1="22.761" y1="-2.667" x2="20.3" y2="3.685" width="0" layer="19" extent="1-1"/>
+</signal>
+<signal name="N$3">
+<contactref element="C58" pad="1"/>
+<contactref element="R31" pad="2"/>
+<contactref element="U1" pad="7"/>
+<wire x1="23.114" y1="-1.496" x2="42.4578125" y2="34.762453125" width="0" layer="19" extent="1-1"/>
+<wire x1="23.721" y1="-2.667" x2="23.114" y2="-1.496" width="0" layer="19" extent="1-1"/>
+</signal>
 </signals>

Commit message: Connected Vbat to VDD, changed umb-detect to 1k from 100 ohms.
Parts:
- R31: value 100 -> 1k
Connections:
- net +3V3: now also U1.6
Changed lines of the file:
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@@
 <?xml version="1.0" encoding="utf-8"?>
 <!DOCTYPE eagle SYSTEM "eagle.dtd">
-<eagle version="6.5.0">
+<eagle version="6.6.0">
 <drawing>
 <settings>
@@
 <attribute name="VALUE" x="53.285" y="45.25" size="1" layer="28" ratio="10" rot="MR270"/>
 </element>
-<element name="R31" library="rcl_custom" package="0402-B-NOSILK" value="100" x="23.241" y="-2.667"/>
+<element name="R31" library="rcl_custom" package="0402-B-NOSILK" value="1k" x="23.241" y="-2.667"/>
 <element name="C58" library="rcl_custom" package="0402-B-NOSILK" value="100n" x="23.114" y="-1.016" rot="R90"/>
 </elements>
@@
 <wire x1="21.336" y1="36.322" x2="21.336" y2="34.445" width="0.1778" layer="16"/>
 <wire x1="21.336" y1="34.445" x2="21.308" y2="34.417" width="0.1778" layer="16"/>
+<contactref element="U1" pad="6"/>
+<wire x1="43.872028125" y1="33.348240625" x2="42.104259375" y2="35.116009375" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="JTAG_TMS">

Commit message: Changed name of umbilical patch to be active low.
Connections:
- net N$3 renamed !UMB_DETECT_MCU
- net UMB-DETECT renamed !UMB-DETECT
Changed lines of the file:
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@@
 <wire x1="51.435" y1="45.72" x2="51.435" y2="44.93" width="0.1778" layer="16"/>
 </signal>
-<signal name="UMB-DETECT">
+<signal name="!UMB-DETECT">
 <contactref element="J14" pad="RR@10"/>
 <contactref element="R31" pad="1"/>
 <wire x1="22.761" y1="-2.667" x2="20.3" y2="3.685" width="0" layer="19" extent="1-1"/>
 </signal>
-<signal name="N$3">
+<signal name="!UMB_DETECT_MCU">
 <contactref element="C58" pad="1"/>
 <contactref element="R31" pad="2"/>
