# Repository psas/avionics-cad

File README.md:

# PSAS Schematics and Board Layouts

Main repo for all schematics and board designs on the rocket. This is
the main work of the [Avionics Team](http://psas.pdx.edu/avionics/).

To get started you'll need EAGLE CAD version 6.2 or greater.

## Directories:

 - `av3`: All files for the current rocket (2011 onwards)
 - `eagle`: CAM and script files and design rules for EAGLE CAD
 - `libraries`: Eagle libraries for differnt parts and projects
 - `lv1`: Historic boards and files for the [LV1 launch vehicle](http://psas.pdx.edu/Projects/#index2h3)
 - `lv2`: Historic boards and files for 2005 [launch of LV2.3](http://psas.pdx.edu/news/2005-08-20/)

## Naming Convention

    (rocketname)-(system-name)-[(sub-board-name)-][(sub-sub-board-name)-](version)

 - node1 = CAN Node v1, which was the PIC16F + SJA1000 design
 - node2 = CAN Node v2, which was the PIC18F + linear power supply (7805)
 - node3 = CAN Node v3, which was the PIC18F + SPS
 - node4 = USB Node v4, which is (LPC2148 ARM7 + SPSv2) 2006 capstone design
 - node5 = USB Node v5, which is (LPC2468 ARM7 + SPSv3) 2009 capstone design
 - node6 = Ethernet node v6, which is (STM32 Cortex-M4 + SPSv4) 2012 capstone design

## EAGLE design av4/gps-carrier/gps-carrier.brd

Parts:
C1: 10u; C0805
C2: 100p; C0603
COTSGPS: HEMISPHERE_GPS_MOUNT; GPS_CRECENT_OUTLINE
COTSLNA: GPS_LNA
D1: PMLL4150; SOD80C
R1: 300; R0603
SUPERCAP: 220 mF; DSK-HL
SV1: pow+uart; MA04-1
SV2: spare; MA04-2
U$1, U$2, U$3, U$4: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER

Connections:
ALARM: COTSGPS.30 (ALARM), SV2.6
BACKUPRAM: COTSGPS.4 (BACKUP_PWR), D1.C, SUPERCAP.A
DGPS: COTSGPS.19 (DGPS_LOCK), SV2.4
DIFF_LOCK: COTSGPS.18 (DIFF_LOCK), SV2.7
GND: C1.2, C2.2, COTSGPS.7 (GND), COTSGPS.8 (GND), COTSGPS.27 (GND), COTSGPS.28 (GND), SUPERCAP.C, SV1.1, SV2.8
LOCK: COTSGPS.17 (LOCK), SV2.3
unnamed: D1.A, R1.2
unnamed: COTSGPS.34 (RESET), SV2.5
PARTA_TX: COTSGPS.9 (PORTA_TX), SV1.3
PORTA_RX: COTSGPS.10 (PORTA_RX), SV1.2
PPS: COTSGPS.15 (PPS), SV2.2
VCC: C1.1, C2.1, COTSGPS.1 (VCC), COTSGPS.2 (VCC), COTSGPS.3 (ANT_PWR), R1.1, SV1.4, SV2.1

Notes on the sheet:
From Jenner GPS. Vcc = 3.3V TX/RX = STM32 UART

Board: 2 copper layers, 62.0 x 93.0 mm, 13 parts (0 on the bottom side), 12 nets.

## EAGLE design av4/rocketnet-hub/eagle/mcu_page_combined_routed.brd

Parts:
C1, C2, C3, C4, C5, C6, C58, C86: 100n; 0402-B-NOSILK
C8, C9: 2.2u/Low ESR; 0402-B-NOSILK
C46, C47: 1u; 0603-B-NOSILK
C106, C107: 10p; 0402-B-NOSILK
E5: TBD/FB; 0603-B
J5: BOOT0 Jumper; 1.27MM_2X1
J10: UART Header; INLINE
J11: I2C Header; 1.27MM_3X1
J12: BOOT1 Jumper; 1.27MM_2X1
J22: Debug Header; 1.27MM_2X5
LED37: LED_RGB_PLCC-6; PLCC-6
Q1: NTR4101P; SOT23
R12, R64, R65, R130, R150: 10k; 0402-B-NOSILK
R15, R17: 2.2k; 0402-B-NOSILK
R25: 200; 0402-B-NOSILK
R31, R147, R148: 1k; 0402-B-NOSILK
R44: 110; 0402-B-NOSILK
R45: 400; 0402-B-NOSILK
R46: 750; 0402-B-NOSILK
R167, R168: 100; 0402-B-NOSILK
TP36, TP37, TP38, TP39: TPTP06R; TP06R
U1: STM32F407V100-PIN_QFP; LQFP-100
U3: SN65220DBV; SOT23-6L
X1: 25 MHz; 8Y

Connections:
25MHZ_REF_CLK_KSZ: R25.1; also elsewhere on the board
25MHZ_REF_CLK_STM: R25.2, U1.66 (PC9)
!UMB-DETECT: R31.1; also elsewhere on the board
!UMB_DETECT_MCU: C58.1, R31.2, U1.7 (PC13)
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C46.1, E5.1, J5.2, J12.2, Q1.2 (S), R12.1, R15.1, R17.1, R44.2, R45.2, R46.2, R147.2, R168.2, U1.6 (VBAT), U1.11 (VDD1), U1.19 (VDD2), U1.28 (VDD3), U1.50 (VDD4), U1.75 (VDD5), U1.100 (VDD6); also elsewhere on the board
ACOK: U1.81 (PD0); also elsewhere on the board
BAT_IMON: U1.25 (PA2); also elsewhere on the board
BOOT0: J5.1, R64.1, U1.94 (BOOT0)
BOOT1: J12.1, R150.1, U1.37 (PB2)
ETH_EN: R130.1, U1.61 (PD14); also elsewhere on the board
ETH_RST_N: U1.85 (PD4); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C46.2, C47.2, C58.2, C86.2, C106.1, C107.1, J10.4 (GND), J11.3 (GND), J22.GND, J22.GND@2 (GND), R64.2, R65.1, R130.2, R148.1, R150.2, TP39.TP, U1.10 (VSS1), U1.20 (VSSA), U1.27 (VSS2), U1.47 (PB10), U1.74 (VSS3), U1.99 (VSS4), U3.2 (GND), U3.5 (GND2), X1.2 (3), X1.4 (3); also elsewhere on the board
IMON_A0: U1.88 (PD7); also elsewhere on the board
IMON_A1: U1.55 (PD8); also elsewhere on the board
JTAG_TCK: J22.TCK, U1.76 (PA14)
JTAG_TDI: J22.TDI, U1.77 (PA15)
JTAG_TDO: J22.TDO, U1.89 (PB3)
JTAG_TMS: J22.TMS, U1.72 (PA13)
JTAG_TRST: TP36.TP, U1.90 (PB4)
MCOL: U1.26 (PA3); also elsewhere on the board
MCRS: U1.23 (PA0); also elsewhere on the board
MRXC: U1.24 (PA1); also elsewhere on the board
MRXD0: U1.33 (PC4); also elsewhere on the board
MRXD1: U1.34 (PC5); also elsewhere on the board
MRXD2: U1.35 (PB0); also elsewhere on the board
MRXD3: U1.36 (PB1); also elsewhere on the board
MRXDV: U1.32 (PA7); also elsewhere on the board
MTXC: U1.18 (PC3); also elsewhere on the board
MTXD0: U1.51 (PB12); also elsewhere on the board
MTXD1: U1.52 (PB13); also elsewhere on the board
MTXD2: U1.17 (PC2); also elsewhere on the board
MTXD3: U1.95 (PB8); also elsewhere on the board
MTXEN: U1.48 (PB11); also elsewhere on the board
unnamed: C106.2, U1.13 (PH1), X1.1
unnamed: C8.1, U1.49 (VCAP_1)
unnamed: C107.2, U1.12 (PH0), X1.3 (2)
unnamed: Q1.3 (D), R148.2, R167.1, U3.4 (B), U3.6 (A)
unnamed: LED37.6 (K), U1.60 (PD13)
unnamed: LED37.2 (K), U1.59 (PD12)
unnamed: LED37.5 (K), U1.58 (PD11)
unnamed: LED37.1 (A), R46.1
unnamed: LED37.3 (A), R45.1
unnamed: LED37.4 (A), R44.1
unnamed: C47.1, C86.1, E5.2, U1.21 (VREF+), U1.22 (VDDA)
unnamed: C9.1, U1.73 (VCAP_2)
unnamed: J22.VTREF, R168.1
unnamed: J22.GNDDET, TP38.TP
NODE1_4_IMON: U1.15 (PC0); also elsewhere on the board
NODE1_!EN: U1.97 (PE0); also elsewhere on the board
NODE1_!FLT: U1.39 (PE8); also elsewhere on the board
NODE2_!EN: U1.98 (PE1); also elsewhere on the board
NODE2_!FLT: U1.40 (PE9); also elsewhere on the board
NODE3_!EN: U1.1 (PE2); also elsewhere on the board
NODE3_!FLT: U1.41 (PE10); also elsewhere on the board
NODE4_!EN: U1.2 (PE3); also elsewhere on the board
NODE4_!FLT: U1.42 (PE11); also elsewhere on the board
NODE5_8_IMON: U1.16 (PC1); also elsewhere on the board
NODE6_!EN: U1.4 (PE5); also elsewhere on the board
NODE6_!FLT: U1.44 (PE13); also elsewhere on the board
NODE7_!EN: U1.5 (PE6); also elsewhere on the board
NODE7_!FLT: U1.45 (PE14); also elsewhere on the board
NODE8_!EN: U1.38 (PE7); also elsewhere on the board
NODE8_!FLT: U1.46 (PE15); also elsewhere on the board
ROCKET_RDY: R167.2; also elsewhere on the board
ROCKET_RDY_MCU: Q1.1 (G), R147.1, U1.83 (PD2)
RST_N: J22.!RESET, R12.2, TP37.TP, U1.14 (NRST)
SCL: J11.1 (SCL), R17.2, U1.92 (PB6); also elsewhere on the board
SDA: J11.2 (SDA), R15.2, U1.93 (PB7); also elsewhere on the board
SPI3_MISO: R65.2, U1.79 (PC11)
SPI3_MOSI: U1.80 (PC12); also elsewhere on the board
SPI3_SCK: U1.78 (PC10); also elsewhere on the board
STM32_RX: J10.2 (STM32_RX), U1.69 (PA10)
STM32_TX: J10.1 (STM32_TX), U1.68 (PA9)
SYNC: U1.67 (PA8); also elsewhere on the board

Notes on the sheet:
Debug Header
Rocket Ready Interface
Boot Configuration
KSZ8999 Power Supply Enable
KS8999 Interface
UART Interface
Ferrite bead position before/after capacitors
Umbilical Detect

Notices in the files:
parts and their libraries:
SparkFun-Passives: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
