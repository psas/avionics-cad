# Repository psas/avionics-cad (continued)

## EAGLE design av4/rocketnet-hub/eagle/mcu_page_combined_routed.brd (continued)

Parts:
C7, C29, C30, C33, C34, C35, C36, C37, C38, C40, C41, C42, C44, C45, C48, C49, C50, C51, C53, C54, C55, C57, C126, C127, C128, C129, C130, C132: 1n; 0402-B-NOSILK
C10, C11: 100n; 0402-B-NOSILK
C87, C88, C90, C91, C92, C93: 2.2u/40V; 0603-B-NOSILK
C89: 2.2u; 0603-B-NOSILK
C95, C96, C97, C98, C99, C100, C101: TBD; 0402-B-NOSILK
J1, J2, J3, J4, J6, J7, J8: ROCKETNET-CONNECTOR-16M; ROCKETNET-M-16
J15, J16, J17, J18, J19, J20, J21: Auxiliary Header; INLINE
L2, L3, L4, L5, L6, L7, L8, L9, L10, L11, L12, L13, L14, L15: ACM2012; TDK-ACM2012
LED2, LED4, LED7, LED10, LED12, LED15, LED18: RED; CHIPLED_0603
LED3, LED6, LED8, LED11, LED14, LED16, LED39: GREEN; CHIPLED_0603
R18, R21, R22, R27, R29, R34, R35, R40, R41, R59, R61, R108, R109, R113, R114: 10k; 0402-B-NOSILK
R19, R23, R26, R30, R33, R36, R39, R50, R53, R57, R63, R107, R110, R112: 750; 0402-B-NOSILK
R49, R52, R54, R56, R58, R60, R62: 69.8k; 0402-B-NOSILK
R51, R66, R67, R68, R69, R70, R71, R121, R122, R123, R124, R125, R126, R127: TBD; 0402-B-NOSILK
R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98, R103, R104, R105, R106, R149, R151, R152, R153, R154, R155, R156, R157, R158, R159, R160, R161, R162, R163: 51; 0402-B-NOSILK
T3, T4, T5, T6, T7, T8, T9, T10, T11, T12, T13, T14, T15, T16: ALT4532; TDK-ALT4532
TP29, TP30, TP31, TP32, TP33, TP34, TP35: TPTP06R; TP06R
U7, U8, U9, U10, U11, U12, U13: TPS2420QFN-16; QFN-306
U14, U15: MAX4734ETC+; TQFN-12

Connections:
+2V1: C36.2, C40.2, C44.2, C45.2, C51.2, C57.2, C130.2, T3.6, T4.6, T5.6, T6.6, T7.6, T8.6, T9.6, T10.6, T11.6, T12.6, T13.6, T14.6, T15.6, T16.6; also elsewhere on the board
+3V3: C10.1, C11.1, R19.2, R21.2, R22.2, R23.2, R26.2, R27.2, R29.2, R30.2, R33.2, R34.2, R35.2, R36.2, R39.2, R40.2, R41.2, R50.2, R53.2, R57.2, R59.2, R61.2, R63.2, R107.2, R108.2, R109.2, R110.2, R112.2, R113.2, R114.2, U14.4 (EN), U14.6 (V+), U15.4 (EN), U15.6 (V+); also elsewhere on the board
+18V: C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, C93.1, U7.1 (IN), U7.2 (IN), U7.3 (IN), U7.4 (IN), U8.1 (IN), U8.2 (IN), U8.3 (IN), U8.4 (IN), U9.1 (IN), U9.2 (IN), U9.3 (IN), U9.4 (IN), U10.1 (IN), U10.2 (IN), U10.3 (IN), U10.4 (IN), U11.1 (IN), U11.2 (IN), U11.3 (IN), U11.4 (IN), U12.1 (IN), U12.2 (IN), U12.3 (IN), U12.4 (IN), U13.1 (IN), U13.2 (IN), U13.3 (IN), U13.4 (IN); also elsewhere on the board
GND: C7.1, C10.2, C11.2, C29.1, C30.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C40.1, C41.1, C42.1, C44.1, C45.1, C48.1, C49.1, C50.1, C51.1, C53.1, C54.1, C55.1, C57.1, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C126.1, C127.1, C128.1, C129.1, C130.1, C132.1, J1.B-@1 (B-), J1.B-@2 (B-), J2.B-@1 (B-), J2.B-@2 (B-), J3.B-@1 (B-), J3.B-@2 (B-), J4.B-@1 (B-), J4.B-@2 (B-), J6.B-@1 (B-), J6.B-@2 (B-), J7.B-@1 (B-), J7.B-@2 (B-), J8.B-@1 (B-), J8.B-@2 (B-), R18.1, R49.1, R51.1, R52.1, R54.1, R56.1, R58.1, R60.1, R62.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R121.1, R122.1, R123.1, R124.1, R125.1, R126.1, R127.1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; also elsewhere on the board
IMON_A0: U14.12 (A0), U15.12 (A0); also elsewhere on the board
IMON_A1: U14.10 (A1), U15.10 (A1); also elsewhere on the board
unnamed: R51.2, U7.7 (IMAX)
unnamed: R66.2, U8.7 (IMAX)
unnamed: J4.T-@9 (TX-), J4.T-@11 (TX-), L8.2
unnamed: C33.2, R83.2, R84.2
unnamed: R18.2, U15.1 (N1)
unnamed: J1.T-@9 (TX-), J1.T-@11 (TX-), L2.2
unnamed: J1.T+@13 (TX+), J1.T+@14 (TX+), L2.1
unnamed: L4.4, T8.5
unnamed: L2.3, T5.4
unnamed: L8.4, T10.5
unnamed: L9.3, T6.4
unnamed: LED3.A, R23.1
unnamed: LED2.A, R19.1
unnamed: LED4.A, R26.1
unnamed: LED6.A, R30.1
unnamed: LED7.A, R33.1
unnamed: LED8.A, R36.1
unnamed: LED10.A, R39.1
unnamed: LED11.A, R53.1
unnamed: LED12.A, R57.1
unnamed: LED14.A, R63.1
unnamed: LED15.A, R107.1
unnamed: LED16.A, R110.1
unnamed: LED18.A, R112.1
unnamed: R121.2, U12.8 (IFLT)
unnamed: R122.2, U11.8 (IFLT)
unnamed: R123.2, U13.8 (IFLT)
unnamed: R124.2, U10.8 (IFLT)
unnamed: R126.2, U8.8 (IFLT)
unnamed: R127.2, U7.8 (IFLT)
unnamed: J1.R+@5 (RX+), J1.R+@7 (RX+), L9.1
unnamed: L10.3, T4.4
unnamed: J6.A1 (AUX1), J19.4
unnamed: L3.3, T3.4
unnamed: L9.4, T6.5
unnamed: L4.3, T8.4
unnamed: J8.T+@13 (TX+), J8.T+@14 (TX+), L7.1
unnamed: C127.2, R149.1, R151.1
unnamed: L12.3, T7.4
unnamed: J8.R-@3 (RX-), J8.R-@4 (RX-), L15.2
unnamed: L13.3, T9.4
unnamed: J6.T-@9 (TX-), J6.T-@11 (TX-), L6.2
unnamed: L13.4, T9.5
unnamed: R67.2, U9.7 (IMAX)
unnamed: LED39.A, R50.1
unnamed: C95.1, U7.9 (CT)
unnamed: L8.3, T10.4
unnamed: J7.R+@5 (RX+), J7.R+@7 (RX+), L14.1
unnamed: C34.2, R85.2, R86.2
unnamed: L14.3, T16.4
unnamed: J2.R+@5 (RX+), J2.R+@7 (RX+), L10.1
unnamed: R125.2, U9.8 (IFLT)
unnamed: C96.1, U8.9 (CT)
unnamed: C98.1, U13.9 (CT)
unnamed: C99.1, U10.9 (CT)
unnamed: C100.1, U11.9 (CT)
unnamed: C101.1, U12.9 (CT)
unnamed: R68.2, U10.7 (IMAX)
unnamed: R69.2, U13.7 (IMAX)
unnamed: R70.2, U11.7 (IMAX)
unnamed: R71.2, U12.7 (IMAX)
unnamed: LED39.C, U7.14 (!PG)
unnamed: L5.3, T15.4
unnamed: C55.2, R97.1, R98.1
unnamed: C30.2, R81.1, R82.1
unnamed: R152.2, T4.3
unnamed: R153.2, T3.3
unnamed: C29.2, R79.1, R80.1
unnamed: R149.2, T6.3
unnamed: R151.2, T5.3
unnamed: J7.R-@3 (RX-), J7.R-@4 (RX-), L14.2
unnamed: C37.2, R87.1, R88.1
unnamed: R154.2, T7.3
unnamed: R155.2, T8.3
unnamed: C38.2, R89.1, R90.1
unnamed: C48.2, R162.1, R163.1
unnamed: R157.2, T9.3
unnamed: R156.2, T10.3
unnamed: L6.3, T13.4
unnamed: J6.R-@3 (RX-), J6.R-@4 (RX-), L11.2
unnamed: L11.3, T14.4
unnamed: J7.T+@13 (TX+), J7.T+@14 (TX+), L5.1
unnamed: C41.2, R91.1, R92.1
unnamed: C42.2, R93.1, R94.1
unnamed: R162.2, T12.3
unnamed: R163.2, T11.3
unnamed: C49.2, R103.1, R104.1
unnamed: C50.2, R105.1, R106.1
unnamed: R161.2, T14.3
unnamed: R160.2, T13.3
unnamed: C54.2, R95.1, R96.1
unnamed: C7.2, R75.1, R76.1
unnamed: R158.2, T16.3
unnamed: R159.2, T15.3
unnamed: C126.2, R152.1, R153.1
unnamed: C128.2, R154.1, R155.1
unnamed: C129.2, R156.1, R157.1
unnamed: C132.2, R158.1, R159.1
unnamed: LED3.C, U8.14 (!PG)
unnamed: C53.2, R160.1, R161.1
unnamed: C35.2, R77.1, R78.1
unnamed: LED6.C, U9.14 (!PG)
unnamed: L2.4, T5.5
unnamed: L15.3, T12.4
unnamed: J8.T-@9 (TX-), J8.T-@11 (TX-), L7.2
unnamed: J6.T+@13 (TX+), J6.T+@14 (TX+), L6.1
unnamed: J7.T-@9 (TX-), J7.T-@11 (TX-), L5.2
unnamed: J3.T-@9 (TX-), J3.T-@11 (TX-), L4.2
unnamed: J3.T+@13 (TX+), J3.T+@14 (TX+), L4.1
unnamed: J2.T-@9 (TX-), J2.T-@11 (TX-), L3.2
unnamed: J2.T+@13 (TX+), J2.T+@14 (TX+), L3.1
unnamed: J4.T+@13 (TX+), J4.T+@14 (TX+), L8.1
unnamed: L5.4, T15.5
unnamed: L6.4, T13.5
unnamed: L7.4, T11.5
unnamed: L3.4, T3.5
unnamed: J1.R-@3 (RX-), J1.R-@4 (RX-), L9.2
unnamed: J3.R-@3 (RX-), J3.R-@4 (RX-), L12.2
unnamed: J2.R-@3 (RX-), J2.R-@4 (RX-), L10.2
unnamed: J3.R+@5 (RX+), J3.R+@7 (RX+), L12.1
unnamed: L7.3, T11.4
unnamed: J6.R+@5 (RX+), J6.R+@7 (RX+), L11.1
unnamed: J8.R+@5 (RX+), J8.R+@7 (RX+), L15.1
unnamed: L10.4, T4.5
unnamed: L12.4, T7.5
unnamed: J4.R-@3 (RX-), J4.R-@4 (RX-), L13.2
unnamed: J4.R+@5 (RX+), J4.R+@7 (RX+), L13.1
unnamed: L14.4, T16.5
unnamed: L11.4, T14.5
unnamed: L15.4, T12.5
unnamed: TP32.TP, U10.6 (LTCH)
unnamed: LED8.C, U10.14 (!PG)
unnamed: LED14.C, U11.14 (!PG)
unnamed: LED16.C, U12.14 (!PG)
NODE1_4_IMON: U14.8 (COM); also elsewhere on the board
NODE1_!EN: R22.1, U7.16 (!EN); also elsewhere on the board
NODE1_!FLT: LED2.C, R21.1, U7.15 (!FLT); also elsewhere on the board
NODE1_IMON_IN: R49.2, U7.13 (IMON), U14.1 (N1)
NODE1_LTCH: TP29.TP, U7.6 (LTCH)
NODE1_RSV1: J1.A4 (AUX4), J15.1
NODE1_RSV2: J1.A2 (AUX2), J15.3
NODE1_RSV3: J1.A3 (AUX3), J15.2
NODE1_RSV4: J1.A1 (AUX1), J15.4
NODE1_VOUT: J1.B+@15 (B+), J1.B+@16 (B+), U7.10 (OUT), U7.11 (OUT), U7.12 (OUT)
NODE2_!EN: R29.1, U8.16 (!EN); also elsewhere on the board
NODE2_!FLT: LED4.C, R27.1, U8.15 (!FLT); also elsewhere on the board
NODE2_IMON_IN: R52.2, U8.13 (IMON), U14.9 (N2)
NODE2_LTCH: TP30.TP, U8.6 (LTCH)
NODE2_RSV1: J2.A4 (AUX4), J16.1
NODE2_RSV2: J2.A2 (AUX2), J16.3
NODE2_RSV3: J2.A3 (AUX3), J16.2
NODE2_RSV4: J2.A1 (AUX1), J16.4
NODE2_VOUT: J2.B+@15 (B+), J2.B+@16 (B+), U8.10 (OUT), U8.11 (OUT), U8.12 (OUT)
NODE3_!EN: R35.1, U9.16 (!EN); also elsewhere on the board
NODE3_!FLT: LED7.C, R34.1, U9.15 (!FLT); also elsewhere on the board
NODE3_IMON_IN: R54.2, U9.13 (IMON), U14.3 (N3)
NODE3_LTCH: TP31.TP, U9.6 (LTCH)
NODE3_RSV1: J3.A4 (AUX4), J17.1
NODE3_RSV2: J3.A2 (AUX2), J17.3
NODE3_RSV3: J3.A3 (AUX3), J17.2
NODE3_RSV4: J3.A1 (AUX1), J17.4
NODE3_VOUT: J3.B+@15 (B+), J3.B+@16 (B+), U9.10 (OUT), U9.11 (OUT), U9.12 (OUT)
NODE4_!EN: R41.1, U10.16 (!EN); also elsewhere on the board
NODE4_!FLT: LED10.C, R40.1, U10.15 (!FLT); also elsewhere on the board
NODE4_IMON_IN: R58.2, U10.13 (IMON), U14.7 (N4)
NODE4_RSV: J4.A1 (AUX1), J18.4
NODE4_RSV1: J4.A4 (AUX4), J18.1
NODE4_RSV2: J4.A2 (AUX2), J18.3
NODE4_RSV3: J4.A3 (AUX3), J18.2
NODE4_VOUT: J4.B+@15 (B+), J4.B+@16 (B+), U10.10 (OUT), U10.11 (OUT), U10.12 (OUT)
NODE5_8_IMON: U15.8 (COM); also elsewhere on the board
NODE5_!PG: LED11.C, U13.14 (!PG)
NODE5_LTCH: TP33.TP, U13.6 (LTCH)
NODE6_!EN: R109.1, U11.16 (!EN); also elsewhere on the board
NODE6_!FLT: LED15.C, R108.1, U11.15 (!FLT); also elsewhere on the board
NODE6_IMON: R60.2, U11.13 (IMON), U15.9 (N2)
NODE6_LTCH: TP34.TP, U11.6 (LTCH)
NODE6_RSV2: J6.A2 (AUX2), J19.3
NODE6_RSV3: J6.A3 (AUX3), J19.2
NODE6_RSV21: J6.A4 (AUX4), J19.1
NODE6_VOUT: J6.B+@15 (B+), J6.B+@16 (B+), U11.10 (OUT), U11.11 (OUT), U11.12 (OUT)
NODE7_!EN: R114.1, U12.16 (!EN); also elsewhere on the board
NODE7_!FLT: LED18.C, R113.1, U12.15 (!FLT); also elsewhere on the board
NODE7_IMON: R62.2, U12.13 (IMON), U15.3 (N3)
NODE7_LTCH: TP35.TP, U12.6 (LTCH)
NODE7_RSV1: J7.A4 (AUX4), J20.1
NODE7_RSV2: J7.A2 (AUX2), J20.3
NODE7_RSV3: J7.A3 (AUX3), J20.2
NODE7_RSV4: J7.A1 (AUX1), J20.4
NODE7_VOUT: J7.B+@15 (B+), J7.B+@16 (B+), U12.10 (OUT), U12.11 (OUT), U12.12 (OUT)
NODE8_!EN: R61.1, U13.16 (!EN); also elsewhere on the board
NODE8_!FLT: LED12.C, R59.1, U13.15 (!FLT); also elsewhere on the board
NODE8_IMON: R56.2, U13.13 (IMON), U15.7 (N4)
NODE8_RSV1: J8.A4 (AUX4), J21.1
NODE8_RSV2: J8.A2 (AUX2), J21.3
NODE8_RSV3: J8.A3 (AUX3), J21.2
NODE8_RSV4: J8.A1 (AUX1), J21.4
NODE8_VOUT: J8.B+@15 (B+), J8.B+@16 (B+), U13.10 (OUT), U13.11 (OUT), U13.12 (OUT)
RATSNET: C97.1, U9.9 (CT)
RX1_N: R76.2, T5.2; also elsewhere on the board
RX1_P: R75.2, T5.1; also elsewhere on the board
RX2_N: R82.2, T4.2; also elsewhere on the board
RX2_P: R81.2, T4.1; also elsewhere on the board
RX3_N: R84.1, T8.2; also elsewhere on the board
RX3_P: R83.1, T8.1; also elsewhere on the board
RX4_N: R90.2, T9.2; also elsewhere on the board
RX4_P: R89.2, T9.1; also elsewhere on the board
RX6_N: R106.2, T14.2; also elsewhere on the board
RX6_P: R105.2, T14.1; also elsewhere on the board
RX7_N: R96.2, T15.2; also elsewhere on the board
RX7_P: R95.2, T15.1; also elsewhere on the board
RX8_N: R94.2, T12.2; also elsewhere on the board
RX8_P: R93.2, T12.1; also elsewhere on the board
TX1_N: R78.2, T6.2; also elsewhere on the board
TX1_P: R77.2, T6.1; also elsewhere on the board
TX2_N: R80.2, T3.2; also elsewhere on the board
TX2_P: R79.2, T3.1; also elsewhere on the board
TX3_N: R86.1, T7.2; also elsewhere on the board
TX3_P: R85.1, T7.1; also elsewhere on the board
TX4_N: R88.2, T10.2; also elsewhere on the board
TX4_P: R87.2, T10.1; also elsewhere on the board
TX6_N: R104.2, T13.2; also elsewhere on the board
TX6_P: R103.2, T13.1; also elsewhere on the board
TX7_N: R98.2, T16.2; also elsewhere on the board
TX7_P: R97.2, T16.1; also elsewhere on the board
TX8_N: R92.2, T11.2; also elsewhere on the board
TX8_P: R91.2, T11.1; also elsewhere on the board

Notes on the sheet:
Current Switch Select 1-4
Current Switch Select 6-8
Node 5
Node 1
Node 2
Node 3
Node 4
Node 6
Node 7
Node 8
UMBILICAL CABLE - SEE OFF-ROCKET CONNECTORS

Parts:
C52: 4.7u; 0603-B-NOSILK
C84: 4.7u; 1206-B
C85: .1u; 0402-B-NOSILK
C103: 2.2u/40V; 0603-B-NOSILK
C104: 2.2u; 0603-B-NOSILK
J13: PGOOD Jumper; 1.27MM_2X1
LED22: GREEN; CHIPLED_0603
R73: 154k; 0402-B-NOSILK
R74: 49.9k; 0402-B-NOSILK
R128: 750; 0402-B-NOSILK
R131: 10k; 0402-B-NOSILK
TP28: TPTP06R; TP06R
U5: LTM8023; LGA-50
U6: MIC37101-2.1YM; SOIC-8

Connections:
+2V1: C84.1, C85.1, U6.3 (OUT); also elsewhere on the board
+3V3: C52.1, C104.1, R128.1, U5.VOUT@1 (VOUT), U5.VOUT@2 (VOUT), U5.VOUT@3 (VOUT), U5.VOUT@4 (VOUT), U5.VOUT@5 (VOUT), U5.VOUT@6 (VOUT), U5.VOUT@7 (VOUT), U5.VOUT@8 (VOUT), U5.VOUT@9 (VOUT), U5.VOUT@10 (VOUT), U5.VOUT@11 (VOUT), U5.VOUT@12 (VOUT), U6.2 (IN); also elsewhere on the board
+18V: C103.1, U5.RUN/SS, U5.VIN@1 (VIN), U5.VIN@2 (VIN), U5.VIN@3 (VIN), U5.VIN@4 (VIN), U5.VIN@5 (VIN), U5.VIN@6 (VIN); also elsewhere on the board
ETH_EN: U6.1 (EN); also elsewhere on the board
GND: C52.2, C84.2, C85.2, C103.2, C104.2, LED22.C, R73.1, R74.1, R131.2, U5.GND@1 (GND), U5.GND@2 (GND), U5.GND@3 (GND), U5.GND@4 (GND), U5.GND@5 (GND), U5.GND@6 (GND), U5.GND@7 (GND), U5.GND@8 (GND), U5.GND@9 (GND), U5.GND@10 (GND), U5.GND@11 (GND), U5.GND@12 (GND), U5.GND@13 (GND), U5.GND@14 (GND), U5.GND@15 (GND), U5.GND@16 (GND), U5.GND@17 (GND), U5.GND@18 (GND), U5.GND@19 (GND), U5.GND@20 (GND), U5.GND@21 (GND), U5.GND@22 (GND), U5.GND@23 (GND), U5.GND@24 (GND), U6.5 (GND), U6.6 (GND), U6.7 (GND), U6.8 (GND); also elsewhere on the board
unnamed: TP28.TP, U6.4 (FLG)
unnamed: J13.2, LED22.A, U5.PGOOD
unnamed: J13.1, R128.2
unnamed: U5.AUX, U5.BIAS
unnamed: R73.2, U5.ADJ
unnamed: R74.2, U5.RT
SYNC: R131.1, U5.SYNC; also elsewhere on the board

Notes on the sheet:
3.3V Switching Supply
2.1V Linear Supply

## Commit log (part)

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2013-05-10 added new SOIC8 package layout
2013-05-10 Updated schematic with new FDS6680A footprint
2013-05-10 another datasheet, this one has a land pattern
2013-05-10 reloaded libraries
2013-05-13 Added PDF for K.
2013-05-16 Added ACM filters to schematics and layout
2013-05-16 Basic assembly with board and one connector
2013-05-16 both headers in assembly
2013-05-16 standoffs
2013-05-17 explicit 12 pin version
2013-05-17 Updated rocketnet connectors and boards to match new rocketnet stackup.
2013-05-17 battery charger routing updated
2013-05-19 Added 25 MHz crystal package
2013-05-19 removed unused package
2013-05-19 Replaced 25 MHz crystal with 4-SMD crystal component
2013-05-19 Connected GND to GNDA; Replaced LTC with 18-pin header; Redid NodeX_Vout fill; Removed spare capacitor on magnetics
2013-05-19 Added MCU-LTC circuitry
2013-05-21 Fixed/added erroneous component values, removed RST_N signal from the Ethernet reset, fixed naming/pinout on ICs/headers, added frames for each page
2013-05-22 battery charger layout
2013-05-22 parts
2013-05-22 c77-82 changed to 0603-nosilk, removed R166, set pullup/downs that were 10ohm to 0ohm.
2013-05-23 updated layout after parts change, more polys drawn
2013-05-23 Added shunt diode for Ethernet Enable circuitry; added DNI pull-up resistor pads for Mode Select pins on the KSZ8999
2013-05-23 making sure brd and sch stay in sync
2013-05-23 Tidied schematics up; fixed PGOOD jumper
2013-05-24 Tidied up Node Connections page
2013-05-25 Added SPI interface for MCU <-> KSZ8999; approved POWER pin ERC warnings
2013-05-26 Started routing; changed LED status for KS8999
2013-05-26 Routed remaining MII signals
2013-05-28 Cleaned up circuitry under KS8999
2013-05-28 fixed auto router to route brd. 3 nets need manual connection, power fills, and DRC outstanding.
2013-05-29 Removed bad layout file.
2013-05-29 Small changes to ground vias.
2013-05-30 First checkin of Olimex STM32-e407 daughterboard for roll control, called "e407-roll-control".
2013-05-31 removed mtxer pull down and added tp tp pin
2013-06-01 updated battery charger routing
2013-06-02 Added block diagram figure to poster
2013-06-02 Added names to poster
2013-06-02 Added new block diagram files for poster
2013-06-02 Added full schematics image for poster
2013-06-03 Increased thickness on power traces; reexported layout image
2013-06-03 Added 3rd Generation Avionics Block Diagram pdf and original drawing
2013-06-03 added text
2013-06-03 +3V3 poly rank dropped to 2, updated battery charger
2013-06-03 Removed transparancy background from block diagrams
2013-06-03 re-adding eagle files from previous push
2013-06-04 Rerouted board using 7 mil widths and spacing for TX/RX differential pairs
2013-06-04 Added Olimex STm32-E407 to Rocket "C" channel adapter - probably for cutting out of acryllic.
2013-06-04 Updates to the sensor board, these files were made on the LPKF. Includes BOM in xls.
2013-06-05 Fixed DRCs and approved stopmask warnings
2013-06-05 Started fixing autorouter nets
2013-06-05 Fixed missing airwires, added +3v3 fill on bottom board
2013-06-05 wrote some documentationa
2013-06-05 Changed routed traces on GND layer to a different layer
2013-06-05 Removed changes made from previous commit--need to replace KS8999, not delete and add updated part
2013-06-07 battery charger routing clean up
2013-06-07 re-adding datasheets
2013-06-08 battery charger: routing and clean up, attached 18v on top
2013-06-08 fixed all drc issues
2013-06-08 pushed lib
2013-06-09 Added another bom, sorted by value
2013-06-09 Fixed routes
2013-06-09 Cleaned up libraries and updated LDO 2V1 schematic; added silkscreen to FDS6680A
2013-06-09 clean up on routing
2013-06-09 filleted edges on bottom bracket
2013-06-09 minor adjustment after printing bottom bracket
2013-06-09 Started moving component names on silk layer
2013-06-09 extended Vin bottom poly to encompass left pad of C39, adjusted Vin NS poly to compensate for change of C102 from 0805 to 0402 package. Enlarged NS poly.
2013-06-09 Moved more component names on bottom silk layer
2013-06-10 Added PSAS information on top and bottom silk layers
2013-06-10 R151 value changed from 1n to 51
2013-06-10 Updated pulldown resistor component value
2013-06-10 BOM in screaming circuits format
2013-06-10 Updated more bom-sc
2013-06-10 Removed unneeded bom files
2013-06-10 Updated test points on bom
2013-06-10 tps2420 silk and doc updated
2013-06-10 Replaced 2 ohm resistor; updated bom
2013-06-10 Added header parts for bom
2013-06-10 Added USB port digikey part to bom
2013-06-10 Fixed name in silk screen layer
2013-06-11 added battery charger parts
2013-06-12 Various changes to daughterboards, including updating libraries, etc. ISSUE: Connectors still flipped on "bottom" of boards.
2013-06-12 Removed old rocketnet board after double checking newer capstone file coordinates. Also cleaned up outline, and planes in layers 1-3.
2013-06-14 Added R25 in 25 MHz clock line.
2013-06-14 Cleaned up current sense resistor circuitry.
2013-06-15 more power plane cleanup, now of the 2.1V area around the KSZ.
2013-06-15 Cleanup around STM32 - JTAG, UART. Replaced small signal N and P channel MOSFETs with known parts.
2013-06-16 Updated documentation on the Nodes Power and Power Supplies section
2013-06-16 Fixed issues in component selection guide merge
2013-06-17 Fixed typos in documentation
2013-06-17 battery charger components
2013-06-17 Fixed formatting for documentation
2013-06-17 Cleaned up rocketnet connectors 1-3. No DRC errors.
2013-06-17 Cleaned up all but a handful of 5mil traces in an attempt to go with 6/6 instead of 5/5, but that's not going to happen. If I had a nother couple of days, it would be fine. Also checked 6/6 spacing, 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
2013-06-17 Cleaned up paste layer on QFNs, made 6 layer CAM file.
2013-06-17 JJ found a subtle error: Layer 14's VIN plane had thermals, which would have cut down current capability. Fixed.
2013-06-26 Added files on LPC-based roll control module.
2013-07-16 Checked and updated rocketnet hub BOM, adding DK part numbers. Also fixed some values in the EAGLE files to make the BOM collapse correctly. Added some voltage requirements on caps where necessary.
2013-07-19 Updated L1 Mfg part number.
2013-07-29 Update mfg-and-test-log.md
    Notes on what to do next.
2013-08-14 Cleaned up some datasheets.
2013-08-28 Notes from today's hackathon. Also, cleaned up datasheets a bit and started pulling together the board documentation file.
2013-09-04 Added 14 pin (battery board)
2013-09-04 basic upper connector
2013-09-04 top assembly for 16 pin connector
2013-09-11 It works! It works! With comments even.
2013-09-11 Adding some old rocketbus connectors that we forgot to commit a long time ago.
2013-09-11 Update README.md
    Fix links, maybe.
2013-09-11 Starting to clean up component selection documentation.
2013-09-11 To markdown!
2013-09-11 Formatting cleanup; component selection now ready for more content.
2013-09-13 12 pin config now 18 pin for rocketnet umbilical
2013-09-13 Umbilical connector daughterboard and 18 pin female connector.
2013-09-16 regen bottom brackes of all sizes
2013-09-16 More bring up and component design notes after carefully looking over BQ24725 and other power circuitry. Also added more information on modes and mode transitions for the RNH.
2013-09-18 Second iteration of RNH behaviors.
2013-09-24 Added micrel datasheet and latest RNH bring up notes.
2013-09-25 Moved Rocketnet Hub to AV4
2013-09-25 head for 18 pin part
2013-09-28 18 pin rocketnet connector specifically for RNH umbilical cable.
2013-10-02 added new pcb and pin assignments for node6. Added dp83630 library (enet phy)
2013-10-02 enet phy for node6
2013-10-02 Added datasheets for the battery board.
2013-10-02 Moved more files to the eagle directory.
2013-10-09 Updated battery board after reviewing EVM and messing around the BQ3060 with Kenny on the RNH tonight.
2013-10-14 magnetics.lbr: added Pulse H0068ANL ethernet transformer
2013-10-14 added node6 board file to git
2013-10-15 node6: added generic stm32 to pcb for reference (will move to customized symbol). Added datasheets for several parts.
2013-10-16 node6: removed local stm32 library
2013-10-16 node6: node6-specific stm32 library symbol
2013-10-16 Whoops, forgot a new battery board datasheet.
2013-10-23 Latest battery boards notes, handing off to Michael for final polishing.
2013-10-30 Added "mods" to schematic: TP39 to GND, removed R10 and R14.
2013-11-04 rocketnet connector documentation
2013-11-04 typo
2013-11-05 low res mock up of FC stack
2013-11-13 Moved battery board libraries locally.
2013-11-20 renamed node6_pcb --> eagle
2013-11-20 node6: hooked up aux connector to rocketnet
2013-11-26 node6: added ltm8023 power supply
2013-12-02 final routing of battery board. DRC passed. Ready for post-processing and artwork generation.
2013-12-06 Update README.markdown
    Cutting all the #2 bolts to 14.5 mm
2014-01-05 Final cleanup on battery board. Made stitching more focused on power rather than RF, redid shunt library part to be a real kelvin connection (see Analog Devices cute write up on Kelvin sense shunt re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
2014-01-08 Generated BOM and made a Digi-Key order. Found an ERC error that popped up, double checked part values in writeup.
2014-01-09 Added CAT6 color codes
2014-01-09 first pass at 3D printed right angle connector for RNH
2014-01-09 top level gitignore for Eagle stuff
2014-01-12 Another try on the rocketnet connector: expanded drills (0.9 mm), added second 45 degree for fun.
2014-01-14 small plastic nut for rocket net connectors
2014-01-22 Added raspberry pi stuff gleaned off the web. It's all terrible.
2014-01-22 Some keep outs away from hardware, notes for paul.
2014-01-24 Added scan of RP bottom side at 2400 dpi (sorry, it's 50 MB!). Used that to verify P5 and P4 placement. Updated EAGLE library schematic and footprint to be better.
2014-01-25 More on the RP carrier: added the ethernet connector wiring, and LED randomly, and first pass of the power switchers using TI's simple switchers because we're lazy and they're relatively cheap for a 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
2014-01-27 checking in the raspi freecad doc because why not
2014-01-27 RA connector STLs for print
2014-02-11 Draft 1 of RNC to RasPi daughterboard layout
2014-02-26 Fixed gearcam transistor (no 5V to the RP!!11!), made power wires bigger, fixed tname.
2014-02-26 Updated LED connections
2014-03-15 Added .cam file directory removal.
2014-03-15 Should have added these earlier; these are the CAD files for the Sparkfun boards we're using on the IMU sensor shield.
2014-03-15 Being OCD here: it's not the FC holder, it's the avionics module holder.
2014-05-28 starting wifi carrier board
2014-05-28 switcher layout
2014-05-28 change usb binout on wificarrer
2014-05-28 adding caps to wifi carrier
2014-05-28 first shot at wifi carrier board
2014-05-28 rearrange caps and minor bolt adjustment on wifi carrier
2014-05-28 wifi-carrier: power route with polygons
2014-05-30 More isolation on fasteners, better tplace/tname.
2014-06-01 So this is markdown...
2014-06-06 add headers
2014-06-06 blank board design
2014-06-08 Latest patches on the RNH: added connections for port 8, added proposed umbilical disconect patch. Still to do: vbat, and a checklist to make sure we have both RNHs up to the same patch level.
2014-06-11 Connected Vbat to VDD, changed umb-detect to 1k from 100 ohms.
2014-06-18 No BusPirate? Dump directly from the FC.
2014-06-21 New GPS board layout, trying it in the real world.
2014-06-21 Fixed unplated through #4 standoff.
2014-06-21 Oh yeah, board name and version.
2014-06-22 Updated RasPi 0.1" header position and hole placement, as well as added a new 3rd hole. Extended board to have more room for RNC, moved resistor, version is now 2!
2014-06-22 Holds the debug umbilical connector to C channel
2014-06-25 Actual documentation on the raspi carrier!
