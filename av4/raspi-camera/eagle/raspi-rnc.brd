# Repository psas/avionics-cad (continued)

## EAGLE design av4/stm32f4-dev-board/v1-psas-dev-board.brd

Parts:
C10, C62: 100n 10V; 0402-C-NOSILK
C20: 2.2u 10V; 0603-C-NOSILK
C29, C30: 18pF 10V; 0402-C-NOSILK
C45, C46, C47, C48, C49, C50: 100nF 10V; 0402-C-NOSILK
C51, C52: 2.2uF 10V; 0603-C-NOSILK
J1: 1.27MM-SWD-CONNECTOR; 1.27MM_2X5
LED2: BLUE; CHIP-LED0603
LED3: GREEN; CHIP-LED0603
LED4: RED; CHIP-LED0603
Q1: NTR4101P; SOT23
R12: 1.5k; 0402-C-NOSILK
R18: 10k; 0402-C-NOSILK
R38, R39: 68; 0402-C-NOSILK
R40: 27; 0402-C-NOSILK
SD1: CON_HIROSE_DM3D(MICROSD); HIROSE_DM3D(MICRO-SD)
TP1: TPTP06R; TP06R
U8: STM32F4V; LQFP100
USB: ZX62D-B-5P8
X1: 25 MHz; CTS406

Connections:
3.3VD: C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, J1.VTREF, Q1.2 (S), R12.2, R18.2, R38.1, R39.1, R40.1, U8.VCAP1 (VCAP_1), U8.VCAP2 (VCAP_2), U8.VDD1, U8.VDD2, U8.VDD3, U8.VDD4, U8.VDD5, U8.VDD6; also elsewhere on the board
!RST: J1.!RESET, R18.1, U8.NRST
EPHY_NRST: U8.PA1; also elsewhere on the board
ETH_CRX_DV: U8.PA7; also elsewhere on the board
ETH_MDC: U8.PC1; also elsewhere on the board
ETH_MDINT: U8.PA3; also elsewhere on the board
ETH_MDIO: U8.PA2; also elsewhere on the board
ETH_RXD0: U8.PC4; also elsewhere on the board
ETH_RXD1: U8.PC5; also elsewhere on the board
ETH_TXD0: U8.PB12; also elsewhere on the board
ETH_TXD1: U8.PB13; also elsewhere on the board
ETH_TX_EN: U8.PB11; also elsewhere on the board
GND: C10.1, C20.1, C29.1, C30.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C62.1, J1.GND, J1.GND@2 (GND), J1.GNDDET, SD1.G1 (PAD), SD1.G2 (PAD), SD1.G3 (PAD), SD1.G4 (PAD), SD1.P6 (6), SD1.S0 (0), SD1.S1 (1), U8.PDR_ON, U8.VSS1, U8.VSS2, U8.VSS3, USB.P5 (GND); also elsewhere on the board
LED2: LED2.C, U8.PD11
LED3: LED3.C, U8.PD13
LED4: LED4.C, U8.PD14
unnamed: LED4.A, R39.2
unnamed: LED3.A, R38.2
unnamed: LED2.A, R40.2
unnamed: TP1.TP, U8.BOOT0
OSC_IN: C30.2, U8.PH0, X1.3 (2)
OSC_OUT: C29.2, U8.PH1, X1.1
OTG_FS_DM: U8.PA11, USB.P2 (D-)
OTG_FS_DP: U8.PA12, USB.P3 (D+)
OTG_FS_VBUS: U8.PA9, USB.P1 (VCC); also elsewhere on the board
PE0: Q1.1 (G), R12.1, U8.PE0
PHY_CLK_25MHZ: U8.PA8; also elsewhere on the board
SDIO_CLK: SD1.P5 (5), U8.PC12
SDIO_CMD: SD1.P3 (3), U8.PD2
SDIO_D0: SD1.P7 (7), U8.PC8
SDIO_D1: SD1.P8 (8), U8.PC9
SDIO_D2: SD1.P1 (1), U8.PC10
SDIO_D3: SD1.P2 (2), U8.PC11
SHLD: C62.2, USB.P$1 (SHLD), USB.P$2 (SHLD), USB.P$3 (SHLD), USB.P$4 (SHLD)
TCK: J1.SWDCLK (SWDCLK/TCK), U8.PA14
TDI: J1.NC (NC/TDI), U8.PA15
TDO: J1.SWO (SWO/TDO), U8.PB3
TMS: J1.SWDIO (SWDIO/TMS), U8.PA13
VDD: C10.2, C20.2, Q1.3 (D), SD1.P4 (4)

Notes on the sheet:
MICROSD

Parts:
C1: 1uF 50V; 0805-B-NOSILK
C21: 220nF 10V; 0402-C-NOSILK
C25, C54: 100n; 0402-B-NOSILK
C26: 220nF; 0402-C-NOSILK
C33: 10uF 50V; 1206-C
C38: 100u; EIA6032
C39: 1uF; 0603-B-NOSILK
D2: DIODE-0603; 0603-B-NOSILK-DIODE
LED1: GREEN; CHIP-LED0603
R1: 10k; 0402-C-NOSILK
R3: 3.3k; 0402-C-NOSILK
R6: 68; 0402-C-NOSILK
R7: 249k; 0402-C-NOSILK
U10: LMZ12001; TO-PMOD-7
U$1, U$12, U$14, U$18: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER

Connections:
3.3VD: C26.1, C38.P$1 (+), C39.1, C54.1, LED1.A, R1.2, U10.7 (VOUT); also elsewhere on the board
GND: C1.2, C21.2, C25.2, C33.2, C38.P$2 (-), C39.2, C54.2, R3.1, R6.1, U10.4 (GND), U10.EP; also elsewhere on the board
unnamed: C21.1, U10.5 (SS)
unnamed: C26.2, R1.1, R3.2, U10.6 (FB)
unnamed: R7.2, U10.2 (RON)
unnamed: LED1.C, R6.2
OTG_FS_VBUS: D2.ANODE; also elsewhere on the board
VIN: C1.1, C25.1, C33.1, D2.CATHODE, R7.1, U10.1 (VIN); also elsewhere on the board

Notes on the sheet:
4.5 - 26 Vin
Vsys to 3.3V
Aux supply from USB debug
1206
0805

Parts:
C23, C27, C28: 22uF/6.3V; 1206-C
C31, C32, C34, C35, C37, C53: 100nF 10V; 0402-C-NOSILK
C36: 10uF/6.3V; 1206-C
C44: 1nF 10V; 0402-C-NOSILK
J3: ROCKETNET-CONNECTOR-16M; ROCKETNET-M-16
L1, L4: ACM2012; TDK-ACM2012
L3: FB0805/600R/200mA(201209-601); 0805-C-NOSILK
R10, R11: 75; 0402-C-NOSILK
R15: 150; 0402-C-NOSILK
R16: 2.2k; 0402-C-NOSILK
R20: 0R; 0402-C-NOSILK
R22, R23, R24, R25: 49.9R/1%; 0402-C-NOSILK
R27, R42, R43, R44, R45, R46, R47, R48: 4.7k; 0402-C-NOSILK
R28: 10k; 0402-C-NOSILK
R29: 12.1k/1%; 0402-C-NOSILK
T1, T2: ALT4532; TDK-ALT4532
TP22, TP26, TP32, TP33: TEST-POINT; 2MM-TEST-POINT
U3: LAN8710A-EZC; QFN-32(DRILLS)

Connections:
3.3VD: C27.2, C28.2, C35.1, L3.2, R16.1, R27.1, R28.1, R42.1, R43.1, R44.1, R45.1, U3.12 (VDDIO); also elsewhere on the board
AUX1: J3.A1 (AUX1), TP22.1
AUX2: J3.A2 (AUX2), TP26.1
AUX3: J3.A3 (AUX3), TP32.1
AUX4: J3.A4 (AUX4), TP33.1
EPHY_NRST: C36.2, R28.2, U3.19 (NRST); also elsewhere on the board
ETH_CRX_DV: R45.2, U3.15 (COL/CRS_DV/MODE2); also elsewhere on the board
ETH_MDC: U3.17 (MDC); also elsewhere on the board
ETH_MDINT: R15.1, R16.2; also elsewhere on the board
ETH_MDIO: R44.2, U3.16 (MDIO); also elsewhere on the board
ETH_RXD0: R42.2, U3.11 (RXD0/MODE0); also elsewhere on the board
ETH_RXD1: R43.2, U3.10 (RXD1/MODE1); also elsewhere on the board
ETH_TXD0: U3.22 (TXD0); also elsewhere on the board
ETH_TXD1: U3.23 (TXD1); also elsewhere on the board
ETH_TX_EN: U3.21 (TXEN); also elsewhere on the board
GND: C23.1, C27.1, C28.1, C31.1, C32.1, C34.1, C35.2, C36.1, C37.1, C44.1, C53.1, J3.B-@1 (B-), J3.B-@2 (B-), R29.1, R46.2, R47.2, R48.2, U3.24 (TXD2), U3.25 (TXD3), U3.GND; also elsewhere on the board
unnamed: J3.T+@13 (TX+), J3.T+@14 (TX+), L1.1
unnamed: C44.2, R10.1, R11.1
unnamed: J3.T-@9 (TX-), J3.T-@11 (TX-), L1.2
unnamed: J3.R+@5 (RX+), J3.R+@7 (RX+), L4.1
unnamed: J3.R-@3 (RX-), J3.R-@4 (RX-), L4.2
unnamed: L1.4, T1.1
unnamed: L1.3, T1.2
unnamed: L4.4, T2.1
unnamed: L4.3, T2.2
unnamed: R11.2, T1.6
unnamed: R10.2, T2.6
unnamed: R22.1, T2.4, U3.30 (RXN)
unnamed: R25.1, T1.5, U3.29 (TXP)
unnamed: R24.1, T1.4, U3.28 (TXN)
unnamed: R23.1, T2.5, U3.31 (RXP)
unnamed: R29.2, U3.32 (RBIAS)
unnamed: C37.2, R20.1, T1.3, T2.3
unnamed: C34.2, C53.2, U3.6 (VDDCR)
unnamed: R15.2, U3.18 (NINT/TXER/TXD4)
PHYAD0: R46.1, U3.13 (RXER/RXD4/PHYAD0)
PHYAD1: R47.1, U3.7 (RXCLK/PHYAD1)
PHYAD2: R48.1, U3.8 (RXD3/PHYAD2)
PHY_CLK_25MHZ: U3.5 (XTAL1/CLKIN); also elsewhere on the board
RMIISEL: R27.2, U3.9 (RXD2/RMIISEL)
VDDA: C23.2, C31.2, C32.2, L3.1, R20.2, R22.2, R23.2, R24.2, R25.2, U3.1 (VDD2A), U3.27 (VDD1A)
VIN: J3.B+@15 (B+), J3.B+@16 (B+); also elsewhere on the board

Notes on the sheet:
ETHERNET PHY
Common Mode Filters
Pulse Transformers

Board: 4 copper layers, 65.8 x 43.9 mm, 88 parts (0 on the bottom side), 72 nets.

## EAGLE design av4/battery-board/eagle/battery-board.brd

File av4/battery-board/README.md:

# AV4 Battery Board

This is a combined fuel gage, battery protection, cell balancing Smart Battery System PCB based on the BQ3060 "SBS 1.1-COMPLIANT GAS GAUGE and PROTECTION with CEDV".

# CAD and CAM

- All electronic CAD data is in the [eagle](eagle) directory.
- Design notes, Bill of Material (BOM), and functional requirements are in the [documentation](documentation) directory.
- All CAM data is in the TBD CAM directory.

# History

This board has *also* been a long time in the making. It was originally envisioned by Andrew back in 2009, started but placed on hold, and then all but finished by Bob in 2013. With the completion of the RocketNet Hub, this became the next most important project was thus picked back up by Kenny and Andrew Fall 2013. Michael finally finished it off in December 2013, and it was sent to production in Jan 2014.

# For more information

Please see <http://psas.pdx.edu/avionics>.

Parts:
B100A, B101A, B102A, B103A: LIPO-8AHR; LIPO-8AHR-PAC
C101, C102, C105, C109, C111, C112, C113, C114: 100n; 0603-B-NOSILK
C103, C104: 1u 40V; 0603-B-NOSILK
C110: 1u; 0603-B-NOSILK
C115, C116, C117, C118: 100n/50V; 0603-B-NOSILK
D100: SMBJ20A; SMBJ
D101, D102: DIODE-0603; 0603-B-NOSILK-DIODE
F100: 0501010.WR; 1206
J100: ROCKETNET-BATTERY-14; ROCKETNET-M-14
J101, J102: 87758-0216
Q100: Si2343DS-T1; SOT23
Q101, Q102: SI4413ADY-T1-E3; SO-8
Q103, Q104: SI1023X; SOT-563
R100: 249 0.5W; 1206-B
R101, R103, R104: 1M; 0603-B-NOSILK
R102, R109, R111, R119: 1K; 0603-B-NOSILK
R105, R110, R116, R122: 100 .25W; 0603-B-NOSILK
R106, R107, R108: 5.1k; 0603-B-NOSILK
R120, R121: 100; 0603-B-NOSILK
R123: 0.01 5W 1% 75ppm; VISHAY-2818
TP100, TP101, TP102, TP103, TP106, TP107, TP108, TP109, TP110: TEST-POINT; 2MM-TEST-POINT
U100: BQ3060PW; PW-R-PDSO-G24

Connections:
!PRES: J100.!PRSNT@9 (!PRSNT), J100.!PRSNT@10 (!PRSNT), TP106.1, U100.17 (!PRES)
B12: B100A.B+@1 (B+), B100A.B+@2 (B+), B101A.B-@1 (B-), B101A.B-@2 (B-), Q104.1 (S), R116.1, R119.1
B23: B101A.B+@1 (B+), B101A.B+@2 (B+), B102A.B-@1 (B-), B102A.B-@2 (B-), Q104.4 (S), R110.1, R111.1
B34: B102A.B+@1 (B+), B102A.B+@2 (B+), B103A.B-@1 (B-), B103A.B-@2 (B-), Q103.1 (S), R105.1, R109.1
B+: B103A.B+@1 (B+), B103A.B+@2 (B+), C116.1, D101.ANODE, Q101.1 (S), Q101.2 (S), Q101.3 (S), Q103.4 (S), R102.1, R103.1
BAR_GND: B100A.B-@1 (B-), B100A.B-@2 (B-), C101.1, C102.1, C103.2, C104.2, C105.1, C109.2, C110.2, C111.1, C113.2, C114.1, J101.2, J102.2, R122.1, R123.1@1 (1), R123.1@2 (1), TP110.1, U100.19 (VSS)
BAT: C103.1, D101.CATHODE, U100.1 (BAT)
FUSE: TP103.1, U100.21 (FUSE)
unnamed: R120.1, R123.K1
unnamed: C111.2, C112.1, R120.2, U100.7 (SRP)
unnamed: C112.2, C113.1, R121.2, U100.8 (SRN)
unnamed: Q104.3 (D), R116.2
unnamed: C102.2, Q103.2 (G), R109.2, U100.4 (VC2)
unnamed: C105.2, Q104.5 (G), R111.2, U100.5 (VC3)
unnamed: C114.2, Q104.2 (G), R119.2, U100.6 (VC4)
unnamed: C109.1, U100.18 (RBI)
unnamed: C110.1, U100.20 (REG27)
unnamed: C115.1, C118.2
unnamed: R121.1, R123.K2
unnamed: Q104.6 (D), R122.2
unnamed: C101.2, Q103.5 (G), R102.2, U100.3 (VC1)
unnamed: Q103.6 (D), R110.2
unnamed: Q103.3 (D), R105.2
unnamed: R106.2, TP100.1, U100.2 (DSG)
unnamed: Q101.5 (D), Q101.6 (D), Q101.7 (D), Q101.8 (D), Q102.5 (D), Q102.6 (D), Q102.7 (D), Q102.8 (D), R100.2
unnamed: R108.2, TP102.1, U100.22 (ZVCHG)
unnamed: R107.2, TP101.1, U100.23 (CHG)
unnamed: Q101.4 (G), R103.2, R106.1
unnamed: Q102.4 (G), R104.2, R107.1
unnamed: Q100.1 (G), R101.2, R108.1
unnamed: C116.2, C117.1
PACK: C104.1, D102.CATHODE, U100.24 (PACK)
PACK+: F100.1, J100.B+@1 (B+), J100.B+@2 (B+), J100.B+@3 (B+), J100.B+@4 (B+)
PACK+PREFUSE: C117.2, C118.1, D100.C, D102.ANODE, F100.2, Q100.2 (S), Q102.1 (S), Q102.2 (S), Q102.3 (S), R101.1, R104.1
PRE-CHARGE: Q100.3 (D), R100.1
RNC-SCLK: J100.SMCLK@3 (SMCLK), J100.SMCLK@4 (SMCLK), TP107.1, U100.16 (SMBC)
SMBD: J100.SMDAT@7 (SMDAT), J100.SMDAT@8 (SMDAT), TP108.1, U100.14 (SMBD)
T1: J101.1, U100.9 (TS1)
T2: J102.1, U100.10 (TS2)
TRIANGLE_GND: C115.2, D100.A, J100.B-@11 (B-), J100.B-@12 (B-), J100.B-@13 (B-), J100.B-@14 (B-), R123.2@1 (2), R123.2@2 (2), TP109.1

Notes on the sheet:
10K TC
10A
Charging switch
Discharging switch
Precharge switch

Board: 4 copper layers, 71.2 x 35.3 mm, 59 parts (0 on the bottom side), 40 nets.

## EAGLE design av4/node6/eagle/node6-gfe.brd

Parts:
C1, C2, C4, C5: 100n; 0402-B-NOSILK
C3: 1n; 0402-B-NOSILK
J2: ROCKETNET-CONNECTOR-16M; ROCKETNET-M-16
J3: MICROSD-7T-DET504077; MOLEX_504077-1891
J15: Auxiliary Header; INLINE
L1: PULSE-H0068ANL/SO; PULSE-H0068ANL
LED1: LED_RGB_PLCC-6; PLCC-6
R1, R2, R3, R4: 49.9; 0402-B-NOSILK; TOLERANCE 1%
R5, R6: 75.0; 0402-B-NOSILK; TOLERANCE 1%
U1: DP83630/LLP; QFN50P700X700X80-49N
U2: STM32F407V_NODE6/LQFP100; QFP50P1600X1600X160-100N

Connections:
ANA33VDD: U1.19 (ANA33VDD)
ENET_RD+: L1.5 (TD+), R3.2, U1.14 (RD+)
ENET_RD-: L1.6 (TD-), R4.2, U1.13 (RD-)
ENET_TD+: L1.1 (RD+), R1.2, U1.17 (TD+)
ENET_TD-: L1.2 (RD-), R2.2, U1.16 (TD-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J3.T1 (TAB), J3.T2 (TAB), J3.T3 (TAB), J3.T4 (TAB), J3.T5 (TAB), J3.T6 (TAB), J3.T7 (TAB), U1.15 (CD_VSS), U1.18 (ANAVSS), U1.35 (IO_CORE_VSS), U1.47 (IO_VSS), U1.49 (DAP); also elsewhere on the board
IO_VDD: U1.32 (IO_VDD), U1.48 (IO_VDD)
unnamed: U1.1 (TX_CLK), U2.24 (PA1/ETH_RMII_REF_CLK)
unnamed: C1.1, R1.1, R2.1
unnamed: L1.9 (TXCT), R5.2
unnamed: C2.1, R3.1, R4.1
unnamed: L1.10 (RXCT), R6.2
unnamed: C3.1, R5.1, R6.1
unnamed: C4.1, L1.3 (RDCT)
unnamed: C5.1, L1.4 (TDCT)
unnamed: U1.2 (TX_EN), U2.48 (PB11ETH_RMII_TX_EN)
unnamed: U1.3 (TXD_0), U2.51 (PB12/ETH_RMII_TXD0)
unnamed: U1.4 (TXD_1), U2.52 (PB13/ETH_RMII_TXD1)
unnamed: U1.46 (RXD_0), U2.33 (PC4/ETH_RMII_RX_D0)
unnamed: U1.45 (RXD_1), U2.34 (PC5/ETH_RMII_RX_D1)
unnamed: U1.34 (X1), U2.67 (PA8/MCO1)
unnamed: U1.30 (MDIO), U2.25 (PA2/ETH_MDIO)
unnamed: U1.31 (MDC), U2.16 (PC1/ETH_MDC)
RNET_AUX1: J2.A1 (AUX1), J15.1
RNET_AUX2: J2.A2 (AUX2), J15.2
RNET_AUX3: J2.A3 (AUX3), J15.3
RNET_AUX4: J2.A4 (AUX4), J15.4
RNET_B+: J2.B+@15 (B+), J2.B+@16 (B+); also elsewhere on the board
RNET_B-: J2.B-@1 (B-), J2.B-@2 (B-); also elsewhere on the board
RNET_RX+: J2.R+@5 (RX+), J2.R+@7 (RX+), L1.8 (TX+)
RNET_RX-: J2.R-@3 (RX-), J2.R-@4 (RX-), L1.7 (TX-)
RNET_TX+: J2.T+@13 (TX+), J2.T+@14 (TX+), L1.12 (RX+)
RNET_TX-: J2.T-@9 (TX-), J2.T-@11 (TX-), L1.11 (RX-)
SD_CLK: J3.5 (CLK/SCLK), U2.80 (PC12/SDIO_CK)
SD_CMD: J3.3 (CMD/DI), U2.83 (PD2/SDIO_CMD)
SD_DAT0: J3.7 (DAT0/DO), U2.65 (PC8/SDIO_D0)
SD_DAT1: J3.8 (DAT1/RSV), U2.66 (PC9/SDIO_D1)
SD_DAT2: J3.1 (DAT2/RSV), U2.78 (PC10/SDIO_D2)
SD_DAT3: J3.2 (CD/DAT3/!CS), U2.79 (PC11/SDIO_D3)
SD_DETECT: J3.DET
VDD: J3.4 (VDD)
VSS: J3.6 (VSS)

Parts:
C103: 2.2u/40V; 0603-B-NOSILK
C104: 2.2u; 0603-B-NOSILK
C2000: 100n 50V; 0603-B-NOSILK
C2001: 22u 50V; D/7343-31R
C2002: 330n 50V; 0603-B-NOSILK
C2003: 2.7u; 0603-B-NOSILK
C2004: 15n; 0603-B-NOSILK
C2011: 10n 50V; 0603-B-NOSILK
D2001: CDSU101A; 0603-DIODE
F2000: 2.0A Fast; 1206
L2000: CMS1
LED22: GREEN; CHIPLED_0603
Q2000, Q2002: PMV45EN; SOT23
Q2001: Si7309DN; 1212-8_POWERPAK
R73: 93.1k; 0402-B-NOSILK; TOLERANCE 1%
R74: 49.9k; 0402-B-NOSILK
R131: 10k; 0402-B-NOSILK
R2000: 100k; 0603-B-NOSILK
R2001: 61.9k; 0603-B-NOSILK
R2002, R2012: 10k; 0603-B-NOSILK
R2003: .033; 0805-B-NOSILK
R2004: 1k; 0603-B-NOSILK
R2005: 34.0k 1%; 0603-B-NOSILK
R2006: 10k 1%; 0603-B-NOSILK
TVS2000: TVS_SMB; DO-214AA/SMB
U3: LTC3586; QFN40P600X400X75-39N
U5: LTM8023; LGA-50
U2000: MAX5902AAEUT; SOT23-6
U2001: TLV3012AIDBVT; SOT23-6

Connections:
+5V_RAW: C104.1, U3.35 (VBUS), U3.36 (VBUS), U5.VOUT@1 (VOUT), U5.VOUT@2 (VOUT), U5.VOUT@3 (VOUT), U5.VOUT@4 (VOUT), U5.VOUT@5 (VOUT), U5.VOUT@6 (VOUT), U5.VOUT@7 (VOUT), U5.VOUT@8 (VOUT), U5.VOUT@9 (VOUT), U5.VOUT@10 (VOUT), U5.VOUT@11 (VOUT), U5.VOUT@12 (VOUT)
+18V: C103.1, R2003.2, R2004.2, U5.RUN/SS, U5.VIN@1 (VIN), U5.VIN@2 (VIN), U5.VIN@3 (VIN), U5.VIN@4 (VIN), U5.VIN@5 (VIN), U5.VIN@6 (VIN)
BIN: F2000.1, L2000.3
CHASSIS: C2000.1, R2000.1
GND: C103.2, C104.2, C2000.2, C2001.-, C2002.1, C2003.1, C2011.1, L2000.2, LED22.C, Q2000.2 (S), Q2002.2 (S), R73.1, R74.1, R131.2, R2000.2, R2002.1, R2006.1, R2012.1, TVS2000.ANODE, U3.39 (GND), U5.GND@1 (GND), U5.GND@2 (GND), U5.GND@3 (GND), U5.GND@4 (GND), U5.GND@5 (GND), U5.GND@6 (GND), U5.GND@7 (GND), U5.GND@8 (GND), U5.GND@9 (GND), U5.GND@10 (GND), U5.GND@11 (GND), U5.GND@12 (GND), U5.GND@13 (GND), U5.GND@14 (GND), U5.GND@15 (GND), U5.GND@16 (GND), U5.GND@17 (GND), U5.GND@18 (GND), U5.GND@19 (GND), U5.GND@20 (GND), U5.GND@21 (GND), U5.GND@22 (GND), U5.GND@23 (GND), U5.GND@24 (GND), U2000.4 (GND), U2001.2 (V-); also elsewhere on the board
IN+: C2004.1, R2005.1, R2006.2, U2001.3 (IN+)
MAX_UVLO: Q2000.3 (D), R2001.1, R2002.2, U2000.6 (ON_OFF/)
unnamed: U5.AUX, U5.BIAS
unnamed: R73.2, U5.ADJ
unnamed: R74.2, U5.RT
unnamed: Q2001.5-6-7-8 (D), R2003.1
N_DRAIN: Q2002.3 (D), R2004.1, U2000.2 (DRAIN)
N_GATE: C2004.2, Q2002.1 (G), U2001.1 (OUT)
PGOOD_5V: LED22.A, U5.PGOOD
PORT1.0/GPIO_SPS_DISABLE: Q2000.1 (G), R2012.2
PORT1.1/GPIO_SPS_V-IN_GOOD: U2000.5 (PGOOD/)
P_GATE: Q2001.4 (G), U2000.3 (GATE)
REF: U2001.4 (IN-), U2001.5 (REF)
RNET_B+: L2000.4; also elsewhere on the board
RNET_B-: L2000.1; also elsewhere on the board
SPS_OUT: D2001.A (ANODE), R2005.2
SYNC: R131.1, U5.SYNC
V+1: C2003.2, D2001.K (CATHODE), U2001.6 (V+)
V_FUSED: C2001.+, C2002.2, C2011.2, F2000.2, Q2001.1-2-3 (S), R2001.2, TVS2000.CATHODE, U2000.1 (VS)

Notes on the sheet:
Rcb
SPS_OUT Over Voltage Sense
REQUIRES LPC PULL-UP
18.2K if SPS=3.3V
+72V Hot Swap Controller
5V Switching Supply
TODO: Sync, power good, etc.

Board: 4 copper layers, 49 parts (0 on the bottom side), 58 nets, no tracks yet.
