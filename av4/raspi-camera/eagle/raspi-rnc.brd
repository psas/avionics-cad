# Repository psas/avionics-cad (continued)

## EAGLE design av4/rocketnet-hub/eagle/mcu_page_combined_routed.brd (continued)

Parts:
C12: 10n; 0402-B-NOSILK
C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76: 100n; 0402-B-NOSILK
C77, C78, C79, C80, C81, C82: 10u; 0603-A-NOSILK
C83: 0.1u; 0402-B-NOSILK
D1: CDBU0520; 0603-B-NOSILK-DIODE
D2, D3: CDBU0130L; 0603-B-NOSILK-DIODE
LED1, LED5, LED9, LED13, LED17, LED21, LED25, LED29, LED33: AMBER; CHIPLED_0603
LED38: GREEN; CHIPLED_0603
Q8: PMV45EN; SOT23
Q9: NTR4101P; SOT23
Q10: PMV45EN; SOT-23
R1, R5, R9, R16, R20, R24, R28, R32, R38: 750; 0402-B-NOSILK
R2, R3, R4, R6, R7, R8, R72, R116, R117, R118, R119, R120: 0; 0402-B-NOSILK
R10, R14: NP; 0402-B-NOSILK
R13: 3k; 0402-B-NOSILK
R42, R43, R47: 10k; 0402-B-NOSILK
R48: 1.2k; 0402-B-NOSILK
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP40: TPTP06R; TP06R
U4: KS8999; PQFP208

Connections:
25MHZ_REF_CLK_KSZ: U4.176 (X1); also elsewhere on the board
+2V1: C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C78.2, C79.2, C80.2, C81.2, C82.2, D2.CATHODE, Q10.3 (G), R2.2, R3.2, R47.1, R116.2, U4.1 (VDD_RX), U4.4 (VDD_RX1), U4.16 (VDD_TX), U4.17 (VDD_TX1), U4.25 (VDD_RX2), U4.28 (VDD_RX3), U4.36 (VDD_TX2), U4.37 (VDD_TX3), U4.49 (VDD_RX4), U4.52 (VDD_RX5), U4.59 (VDD_TX4), U4.60 (VDD_TX5), U4.67 (VDD_RX6), U4.74 (VDD_RCV), U4.75 (VDD_RCV1), U4.78 (VDD_RCV2), U4.79 (VDD_RCV3), U4.94 (VDD), U4.108 (VDD1), U4.135 (VDD2), U4.157 (VDD3), U4.178 (VDD_PLLTX), U4.182 (VDD_RCV4), U4.183 (VDD_RCV5), U4.186 (VDD_RCV6), U4.187 (VDD_RCV7), U4.194 (VDD_RX7), U4.201 (VDD_TX6), U4.202 (VDD_TX7); also elsewhere on the board
+3V3: Q9.2 (S), R1.2, R5.2, R9.2, R16.2, R20.2, R24.2, R28.2, R32.2, R38.2, R42.1, R48.2; also elsewhere on the board
ETH_EN: D1.CATHODE, R43.2; also elsewhere on the board
ETH_RST_N: D3.CATHODE; also elsewhere on the board
GND: C12.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.1, C82.1, C83.2, Q8.2 (S), Q10.2 (S), R4.1, R6.1, R7.1, R8.1, R10.2, R13.2, R14.1, R72.1, R117.2, R118.2, R119.2, R120.2, U4.2 (GND_RX), U4.3 (GND_RX1), U4.15 (GND_TX), U4.18 (GND-ISO), U4.21 (GND_TX1), U4.24 (GND_RX2), U4.27 (GND-ISO1), U4.29 (GND_RX3), U4.32 (GND_TX2), U4.35 (GND-ISO2), U4.38 (GND_TX3), U4.50 (GND_RX4), U4.51 (GND_RX5), U4.53 (GND-ISO3), U4.56 (GND_TX4), U4.63 (GND_TX5), U4.66 (GND_RX6), U4.68 (FXSD[5]), U4.69 (FXSD[6]), U4.70 (FXSD[7]), U4.71 (FXSD[8]), U4.72 (GND_RCV), U4.73 (GND_RCV1), U4.76 (GND_RCV2), U4.77 (GND_RCV3), U4.95 (GND)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; also elsewhere on the board
LED1-3: LED1.C, U4.111 (LED[1][3])
LED2-3: LED5.C, U4.115 (LED[2][3])
LED3-3: LED9.C, U4.127 (LED[3][3])
LED4-3: LED13.C, U4.131 (LED[4][3])
LED5-3: LED17.C, U4.137 (LED[5][3])
LED6-3: LED21.C, U4.141 (LED[6][3])
LED7-3: LED25.C, U4.145 (LED[7][3])
LED8-3: LED29.C, R14.2, U4.150 (LED[8][3])
LED9-3: LED33.C, U4.158 (LED[9][3])
MCOL: U4.103 (MCOL); also elsewhere on the board
MCRS: U4.104 (MCRS); also elsewhere on the board
MRXC: U4.124 (MRXC); also elsewhere on the board
MRXD0: U4.123 (MRXD[0]); also elsewhere on the board
MRXD1: U4.122 (MRXD[1]); also elsewhere on the board
MRXD2: U4.121 (MRXD[2]); also elsewhere on the board
MRXD3: U4.120 (MRXD[3]); also elsewhere on the board
MRXDV: U4.119 (MRXDV); also elsewhere on the board
MTXC: U4.102 (MTXC); also elsewhere on the board
MTXD0: U4.100 (MTXD[0]); also elsewhere on the board
MTXD1: U4.99 (MTXD[1]); also elsewhere on the board
MTXD2: U4.98 (MTXD[2]); also elsewhere on the board
MTXD3: U4.97 (MTXD[3]); also elsewhere on the board
MTXEN: U4.96 (MTXEN); also elsewhere on the board
unnamed: LED1.A, R1.1
unnamed: TP1.TP, U4.112 (LED[1][2])
unnamed: R8.2, U4.167 (MODESEL[0])
unnamed: TP2.TP, U4.113 (LED[1][1])
unnamed: R7.2, U4.166 (MODESEL[1])
unnamed: TP3.TP, U4.114 (LED[1][0])
unnamed: R6.2, U4.165 (MODESEL[2])
unnamed: Q8.3 (D), Q9.1 (G), R42.2
unnamed: LED5.A, R5.1
unnamed: TP4.TP, U4.116 (LED[2][2])
unnamed: R4.2, U4.164 (MODESEL[3])
unnamed: TP5.TP, U4.117 (LED[2][1])
unnamed: R10.1, U4.171 (CFGMODE)
unnamed: TP6.TP, U4.118 (LED[2][0])
unnamed: R2.1, U4.163 (MIIS[0])
unnamed: C12.1, D1.ANODE, Q8.1 (G), R43.1
unnamed: R13.1, U4.26 (ISET)
unnamed: LED9.A, R9.1
unnamed: TP7.TP, U4.128 (LED[3][2])
unnamed: TP8.TP, U4.129 (LED[3][1])
unnamed: R3.1, U4.170 (PRSV)
unnamed: TP9.TP, U4.130 (LED[3][0])
unnamed: LED13.A, R16.1
unnamed: TP10.TP, U4.132 (LED[4][2])
unnamed: TP11.TP, U4.133 (LED[4][1])
unnamed: TP12.TP, U4.134 (LED[4][0])
unnamed: LED17.A, R20.1
unnamed: TP13.TP, U4.138 (LED[5][2])
unnamed: TP14.TP, U4.139 (LED[5][1])
unnamed: TP15.TP, U4.140 (LED[5][0])
unnamed: LED21.A, R24.1
unnamed: TP16.TP, U4.142 (LED[6][2])
unnamed: TP17.TP, U4.143 (LED[6][1])
unnamed: TP18.TP, U4.144 (LED[6][0])
unnamed: LED25.A, R28.1
unnamed: TP19.TP, U4.146 (LED[7][2])
unnamed: TP20.TP, U4.147 (LED[7][1])
unnamed: TP21.TP, U4.149 (LED[7][0])
unnamed: R117.1, U4.109 (BIST)
unnamed: LED29.A, R32.1
unnamed: TP22.TP, U4.151 (LED[8][2])
unnamed: R116.1, U4.156 (IO_SWM)
unnamed: TP23.TP, U4.152 (LED[8][1])
unnamed: TP24.TP, U4.153 (LED[8][0])
unnamed: LED33.A, R38.1
unnamed: TP25.TP, U4.159 (LED[9][2])
unnamed: TP26.TP, U4.160 (LED[9][1])
unnamed: TP27.TP, U4.161 (LED[9][0])
unnamed: C83.1, D2.ANODE, D3.ANODE, R47.2, U4.110 (!RST)
unnamed: R118.1, U4.82 (RLPBK)
unnamed: R119.1, U4.169 (SCANEN)
unnamed: R120.1, U4.168 (TESTEN)
unnamed: LED38.A, R48.1
unnamed: R72.2, U4.101 (MTXER)
unnamed: TP40.TP, U4.87 (AUTOMDIX)
unnamed: LED38.C, Q10.1 (D)
RX1_N: U4.197 (RXM[1]); also elsewhere on the board
RX1_P: U4.196 (RXP[1]); also elsewhere on the board
RX2_N: U4.207 (RXM[2]); also elsewhere on the board
RX2_P: U4.206 (RXP[2]); also elsewhere on the board
RX3_N: U4.6 (RXM[3]); also elsewhere on the board
RX3_P: U4.5 (RXP[3]); also elsewhere on the board
RX4_N: U4.23 (RXM[4]); also elsewhere on the board
RX4_P: U4.22 (RXP[4]); also elsewhere on the board
RX5_N: U4.31 (RXM[5]); also elsewhere on the board
RX5_P: U4.30 (RXP[5]); also elsewhere on the board
RX6_N: U4.48 (RXM[6]); also elsewhere on the board
RX6_P: U4.47 (RXP[6]); also elsewhere on the board
RX7_N: U4.55 (RXM[7]); also elsewhere on the board
RX7_P: U4.54 (RXP[7]); also elsewhere on the board
RX8_N: U4.65 (RXM[8]); also elsewhere on the board
RX8_P: U4.64 (RXP[8]); also elsewhere on the board
SPI3_MOSI: U4.92 (SDA); also elsewhere on the board
SPI3_SCK: U4.93 (SCL); also elsewhere on the board
TX1_N: U4.200 (TXM[1]); also elsewhere on the board
TX1_P: U4.199 (TXP[1]); also elsewhere on the board
TX2_N: U4.204 (TXM[2]); also elsewhere on the board
TX2_P: U4.203 (TXP[2]); also elsewhere on the board
TX3_N: U4.10 (TXM[3]); also elsewhere on the board
TX3_P: U4.9 (TXP[3]); also elsewhere on the board
TX4_N: U4.20 (TXM[4]); also elsewhere on the board
TX4_P: U4.19 (TXP[4]); also elsewhere on the board
TX5_N: U4.34 (TXM[5]); also elsewhere on the board
TX5_P: U4.33 (TXP[5]); also elsewhere on the board
TX6_N: U4.44 (TXM[6]); also elsewhere on the board
TX6_P: U4.43 (TXP[6]); also elsewhere on the board
TX7_N: U4.58 (TXM[7]); also elsewhere on the board
TX7_P: U4.57 (TXP[7]); also elsewhere on the board
TX8_N: U4.62 (TXM[8]); also elsewhere on the board
TX8_P: U4.61 (TXP[8]); also elsewhere on the board
VDDIO_IN: C13.2, C14.2, C15.2, C77.2, Q9.3 (D), U4.105 (VDD-IO), U4.125 (VDD-IO1), U4.148 (VDD-IO2)

Notes on the sheet:
Ethernet Start-Up
Ethernet Reset
Mode Select

Parts:
C31, C32, C56, C133: 1n; 0402-B-NOSILK
J9: ROCKETNET-BATTERY-14; ROCKETNET-M-14
J14: ROCKETNET-UMBILICAL-18; ROCKETNET-M-18
L16, L17: ACM2012; TDK-ACM2012
R100, R101, R102, R115, R164, R165: 51; 0402-B-NOSILK
T17, T18: ALT4532; TDK-ALT4532

Connections:
!UMB-DETECT: J14.RR@10 (RR); also elsewhere on the board
+2V1: C56.2, T17.6, T18.6; also elsewhere on the board
BAT: J9.B+@1 (B+), J9.B+@2 (B+), J9.B+@3 (B+), J9.B+@4 (B+); also elsewhere on the board
GND: C31.1, C32.1, C56.1, C133.1; also elsewhere on the board
GNDA: J9.!PRSNT@9 (!PRSNT), J9.!PRSNT@10 (!PRSNT), J9.B-@11 (B-), J9.B-@12 (B-), J9.B-@13 (B-), J9.B-@14 (B-), J14.V-@2 (V-), J14.V-@4 (V-), J14.V-@6 (V-), J14.V-@8 (V-); also elsewhere on the board
unnamed: J14.T-@11 (T-), J14.T-@13 (T-), L16.2
unnamed: L16.3, T18.4
unnamed: L17.3, T17.4
unnamed: J14.R+@5 (R+), J14.R+@7 (R+), L17.1
unnamed: C32.2, R102.1, R115.1
unnamed: J14.R-@1 (R-), J14.R-@3 (R-), L17.2
unnamed: L16.4, T18.5
unnamed: L17.4, T17.5
unnamed: R164.2, T17.3
unnamed: R165.2, T18.3
unnamed: C133.2, R164.1, R165.1
unnamed: C31.2, R100.1, R101.1
unnamed: J14.T+@15 (T+), J14.T+@17 (T+), L16.1
ROCKET_RDY: J14.RR@9 (RR); also elsewhere on the board
RX5_N: R101.2, T18.2; also elsewhere on the board
RX5_P: R100.2, T18.1; also elsewhere on the board
SCL: J9.SMCLK@3 (SMCLK), J9.SMCLK@4 (SMCLK); also elsewhere on the board
SDA: J9.SMDAT@7 (SMDAT), J9.SMDAT@8 (SMDAT); also elsewhere on the board
TX5_N: R115.2, T17.2; also elsewhere on the board
TX5_P: R102.2, T17.1; also elsewhere on the board
VIN: J14.V+@12 (V+), J14.V+@14 (V+), J14.V+@16 (V+), J14.V+@18 (V+); also elsewhere on the board

Notes on the sheet:
Launch Tower Connection
Battery Connector

Parts:
C39: 100n/40V; 0402-B-NOSILK
C43: 1u/40V; 0603-B-NOSILK
C60: 2.2uF/40V; 0805-B-NOSILK
C94, C105: 0.1uF/40V; 0402-B-NOSILK
C102: 2200pF/40V; 0402-B-NOSILK
C108, C109, C111, C112: 0.1uF; 0402-B-NOSILK
C110: 100pF; 0402-B-NOSILK
C113, C124: 1uF/40V; 0603-B-NOSILK
C114, C122: 0.01uF; 0402-B-NOSILK
C115, C121: 1uF; 0603-B-NOSILK
C116: 0.047uF; 0402-B-NOSILK
C117, C118, C123, C125: 10uF/40V; 1206-B
C119, C120: 10uF; 1206-B
D4: BAT54; SOT23
D5: SMAJ18CA; D0-214AC
D6: BAT54C; SOT23
L1: 4.7uH/IHLP2525CZER4R7M01; 2525
Q2, Q3, Q4: FDS6680ASOIC8; SOIC8
Q5, Q7: SIS412DNSOP-8; 1212-8
Q6: BSS138W-7-F; SOT323
R11: 2; R2512
R21-17: 10k; 0402-B-NOSILK
R132: 1M; 0402-B-NOSILK
R133: 3.01M; 0402-B-NOSILK
R134: 10m/PMR18EZPFU10L0/0.5 Watt; 1206-B
R135, R136, R145: 4.02k; 0402-B-NOSILK
R137: 430k; 0402-B-NOSILK
R138: 66.5k; 0402-B-NOSILK
R139: 100k; 0402-B-NOSILK
R142: 316k; 0402-B-NOSILK
R143: 7.5; 0402-B-NOSILK
R144: 10; 0402-B-NOSILK
R146: 10m/WSLP1206R0100FEA/1.0 Watt; 1206-B
U2: BQ24725QFN-20; S-PVQFN-N20

Connections:
+3V3: R21-17.2, R142.1; also elsewhere on the board
+18V: C109.2, C117.1, C118.1, C123.1, C124.1, C125.1, D6.1 (A1), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D), R134.2, U2.1 (ACN); also elsewhere on the board
ACOK: R21-17.1, U2.5 (ACOK); also elsewhere on the board
BAT: C111.2, C112.1, C114.2, C119.1, C120.1, Q4.1 (S), Q4.2 (S), Q4.3 (S), R143.2, R146.2; also elsewhere on the board
BAT_IMON: C110.1, U2.7 (IOUT); also elsewhere on the board
GND: C105.2, C108.2, C110.2, C112.2, C113.2, C121.2, C122.2, Q7.1 (S), Q7.2 (S), Q7.3 (S), R132.2, R138.1, R139.1, U2.14 (GND), U2.P$1 (GND), U2.P$2 (GND), U2.P$3 (GND), U2.P$4 (GND), U2.P$5 (GND), U2.P$6 (GND), U2.P$7 (GND), U2.P$8 (GND), U2.P$9 (GND), U2.POWERPAD (GND); also elsewhere on the board
GNDA: C39.2, C43.2, C60.2, C115.2, C117.2, C118.2, C119.2, C120.2, C123.2, C124.2, C125.2, D5.P$1 (A); also elsewhere on the board
unnamed: C105.1, C113.1, D6.3 (CC), U2.20 (VCC)
unnamed: C94.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.1 (S), Q3.2 (S), Q3.3 (S), Q6.3 (S), R133.1, R135.2
unnamed: Q6.2 (G\), R132.1, R133.2
unnamed: C94.2, C102.2, Q2.4 (G), Q3.4 (G), Q6.1 (D), R136.2
unnamed: C60.1, R11.1
unnamed: C108.1, C109.1, C121.1, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), R134.1, U2.2 (ACP)
unnamed: R135.1, U2.3 (CMSRC)
unnamed: R136.1, U2.4 (ACDRV)
unnamed: R137.1, R138.2, U2.6 (ACDET)
unnamed: C122.1, R139.2, R142.2, U2.10 (ILIM)
unnamed: R144.1, U2.13 (SRP)
unnamed: R143.1, U2.12 (SRN)
unnamed: C111.1, L1.P$1, R144.2, R146.1
unnamed: R145.1, U2.11 (BATDRV)
unnamed: C114.1, Q4.4 (G), R145.2
unnamed: C115.1, D4.1 (A), U2.16 (REGN)
unnamed: C116.1, D4.3 (C), U2.17 (BTST)
unnamed: Q7.4 (G), U2.15 (LODRV)
unnamed: C116.2, L1.P$2, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q7.9 (D), U2.19 (PHASE)
unnamed: Q5.4 (G), U2.18 (HIDRV)
SCL: U2.9 (SCL); also elsewhere on the board
SDA: U2.8 (SDA); also elsewhere on the board
VIN: C39.1, C43.1, C102.1, D5.P$2 (C), D6.2 (A2), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), R11.2, R137.2; also elsewhere on the board

Notes on the sheet:
PSAS Rocketnet Hub Battery Charger Schematic
In-Rush Limiter

Board: 6 copper layers, 112.7 x 76.2 mm, 451 parts (181 on the bottom side), 399 nets.

Other parts of the board:
U$1, U$21, U$22, U$23, U$24: #4-BARE_MOUNTING_HOLE/.300; #4/.300-BARE+STD_NUT_OR_STAR_WASHER

## EAGLE design av4/rocketnet-hub/eagle/magnetics-test/ksz8999-evm-dip-replacement.brd

Parts:
L1, L2: ACM2012; TDK-ACM2012
T1, T2: ALT4532; TDK-ALT4532
TP1, TP2, TP3, TP4, TP6, TP7, TP8, TP9, TP10, TP11: TEST-PAD

Connections:
unnamed: L1.3, T1.4
unnamed: L2.4, T2.5
unnamed: T2.1, TP3.P$1
unnamed: T1.6, T2.6, TP2.P$1
unnamed: L1.4, T1.5
unnamed: T2.2, TP1.P$1
unnamed: T1.2, TP4.P$1
unnamed: T1.1, TP6.P$1
unnamed: L1.2, TP10.P$1
unnamed: L1.1, TP11.P$1
unnamed: L2.1, TP8.P$1
unnamed: L2.3, T2.4
unnamed: L2.2, TP7.P$1
unnamed: T1.3, T2.3, TP9.P$1

Notes on the sheet:
RD+
RD-

Board: 2 copper layers, 12.5 x 15.5 mm, 14 parts (0 on the bottom side), 14 nets.

## EAGLE design av4/rocketnet-hub/eagle/magnetics-test/e407-eth-jack-replacment.brd

Parts:
C1: 100n; 0603-B-NOSILK
CON1: RJLBC-060TC1
L1, L2: ACM2012; TDK-ACM2012
R1, R4: 75; 0603-B-NOSILK
T1, T2: ALT4532; TDK-ALT4532
TP1: TPPAD1-13; P1-13
X3, X7: SSW-103-02-S-D
X5, X6: SSW-104-02-S-S

Connections:
unnamed: L1.3, T1.4
unnamed: L2.4, T2.5
unnamed: L2.1, X5.1
unnamed: C1.1, R1.2, R4.2
unnamed: L1.4, T1.5
unnamed: CON1.8 (RD-), X3.4
unnamed: T1.2, X3.1, X3.6
unnamed: T1.1, X3.2, X3.5
unnamed: CON1.7 (RD+), X3.3
unnamed: CON1.1 (TD+), X7.3
unnamed: T2.1, X7.2, X7.5
unnamed: L2.3, T2.4
unnamed: L1.2, X6.3
unnamed: L2.2, X6.1
unnamed: C1.2, TP1.TP
unnamed: CON1.2 (TD-), X7.4
unnamed: R4.1, T2.3
unnamed: L1.1, X5.2
unnamed: R1.1, T1.3
unnamed: CON1.3 (COM), T1.6, T2.6
unnamed: T2.2, X7.1, X7.6

Notes on the sheet:
E407 connector
Off-board connector
RD+
RD-

Board: 2 copper layers, 48.8 x 19.8 mm, 13 parts (0 on the bottom side), 21 nets.

## EAGLE design av4/wifi-carrier/wifi-carrier.brd

Parts:
BOLT, BOLT1, BOLT2, BOLT3: _4-BARE_MOUNTING_HOLE/.325; _4/.325-BARE+SMALL_TOOL_CLEARANCE
C1, C2: 100n; C0603
C3: 1u; C0805
C4: 33u; C1206
C5: 100u; 7660
CTRL: PTR1PAD1-13; P1-13
J1: ROCKETNET-CONNECTOR-16M; ROCKETNET-M-16
J2: 5V; 2POL254
R1, R2: NP; R0603
U1: UEI15; UEI15_PIN
UWIFI: ZCN-722M
VBATT: PTR1PAD1-13; P1-13
VUSB: PTR1PAD1-13; P1-13

Connections:
CTRL: CTRL.TP, U1.6 (CTRL)
D+: J1.T-@9 (TX-), J1.T-@11 (TX-), UWIFI.4 (D+)
D-: J1.R+@5 (RX+), J1.R+@7 (RX+), UWIFI.3 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.-, J1.B-@1 (B-), J1.B-@2 (B-), J2.2, R2.1, U1.2 (INGND), U1.5 (OUTGND)
TRIM: R1.1, R2.2, U1.4 (TRIM)
USB+: J1.T+@13 (TX+), J1.T+@14 (TX+), UWIFI.2 (VCC), VUSB.TP
USB-: J1.R-@3 (RX-), J1.R-@4 (RX-), UWIFI.5 (GND)
VCC: C1.1, C5.+, J1.B+@15 (B+), J1.B+@16 (B+), U1.1 (VIN), VBATT.TP
VOUT: C2.1, C3.1, C4.1, J2.1, R1.2, U1.3 (VOUT)

Notes on the sheet:
TO PA

Board: 2 copper layers, 68.6 x 67.3 mm, 18 parts (0 on the bottom side), 9 nets.
