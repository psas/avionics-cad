File: av3/rocketnet-hub/eagle/mcu_page.sch (EAGLE design)
At the start: 78 parts, among them J1 ROCKETBUS, J2 ROCKETBUS, J3 ROCKETBUS, J4 ROCKETBUS, J5 ROCKETBUS, J6 ROCKETBUS, J7 ROCKETBUS, J8 ROCKETBUS, Q1 12.000MHz, SW1 SW_MOMENTARY-6X3.5MM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

Commit message: finished io assignment
Parts:
- removed C12, C13, C14, C15: 0.1u, rcl:C-EUC0402
- removed C16, C17, C18, C19: 1u, rcl:C-EUC0603K
- removed C20, C21, C22, C23, C24, C25, C26, C27: (no value), rcl:C-EUC0402K
- removed J1, J2, J3, J4, J5, J6, J7, J8: ROCKETBUS, rocketbus:ROCKETBUS
- removed LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8: (no value), led:LEDSML0603
- removed R1, R2, R3, R4, R5, R6, R7, R8: (no value), rcl:R-US_R0402
- removed R10, R9: 2.5k, rcl:R-US_R0402
- removed U$10, U$11, U$12, U$13: AD5248MSOP-10, RNH_AD5248:AD5248MSOP-10
- removed U$2, U$3, U$4, U$5, U$6, U$7, U$8, U$9: TPS25910QFN-16, RNH_TPS25910:TPS25910QFN-16
- removed X1, X2, X3, X4, X5, X6, X7, X8: 87758-0416, con-molex:87758-0416
- added C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52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: (no value), rcl:C-EUC0402
- added JTAG: BH20R, con-harting-ml:ML20R
- added R-T: Open, jumper:SJSJ_SMALLER
- added R13: 10k, rcl:R-US_R0402
- added R33, R34: NA, rcl:R-EU_R0603_5MIL_DWS_NA
- added RM4: NA(10k), OLIMEX_DISCRET:R_MATRIX_4E
- added RM5: 10k, OLIMEX_DISCRET:R_MATRIX_4E
- added SV1: (no value), con-lstb:MA06-1
- added U$14: KS8999, ks8999:KS8999
Connections:
- net N$3 renamed NODE7_!PG
- net RMII_MDC renamed NODE6_IMON
- net RMII_MDIO renamed NODE1_IMON
- net UART_RX renamed NODE6_!PG
- net UART_TX renamed NODE5_!PG
- removed net +UB: C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, U$10.VDD, U$11.AD0, U$11.VDD, U$12.AD0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
- removed net MCU_RESET_N: R11.1, U$1.NRST
- removed net N$15: C20.1, U$4.GATE
- removed net N$16: C21.1, U$3.GATE
- removed net N$17: C22.1, U$2.GATE
- removed net N$18: C23.1, U$5.GATE
- removed net N$19: C24.1, U$6.GATE
- removed net N$20: C25.1, U$7.GATE
- removed net N$21: C26.1, U$8.GATE
- removed net N$22: C27.1, U$9.GATE
- removed net NODE1_ILIM: U$10.W1, U$2.ILIM
- removed net NODE1_LED: LED1.A, R1.1
- removed net NODE1_RSV1: J1.AUX_2@2, X1-1.S
- removed net NODE1_RSV2: J1.AUX_1@2, X1-2.S
- removed net NODE1_RSV3: J1.AUX_2@1, X1-3.S
- removed net NODE1_RSV4: J1.AUX_1@1, X1-4.S
- removed net NODE1_VOUT: J1.B+@1, J1.B+@2, R1.2, U$2.OUT@10, U$2.OUT@11, U$2.OUT@12
- removed net NODE2_ILIM: U$10.W2, U$3.ILIM
- removed net NODE2_LED: LED2.A, R2.1
- removed net NODE2_RSV1: J2.AUX_2@2, X2-1.S
- removed net NODE2_RSV2: J2.AUX_1@2, X2-2.S
- removed net NODE2_RSV3: J2.AUX_2@1, X2-3.S
- removed net NODE2_RSV4: J2.AUX_1@1, X2-4.S
- removed net NODE2_VOUT: J2.B+@1, J2.B+@2, R2.2, U$3.OUT@10, U$3.OUT@11, U$3.OUT@12
- removed net NODE3_ILIM: U$11.W1, U$4.ILIM
- removed net NODE3_LED: LED3.A, R3.1
- removed net NODE3_RSV1: J3.AUX_2@2, X3-1.S
- removed net NODE3_RSV2: J3.AUX_1@2, X3-2.S
- removed net NODE3_RSV3: J3.AUX_2@1, X3-3.S
- removed net NODE3_RSV4: J3.AUX_1@1, X3-4.S
- removed net NODE3_VOUT: J3.B+@1, J3.B+@2, R3.2, U$4.OUT@10, U$4.OUT@11, U$4.OUT@12
- removed net NODE4_ILIM: U$11.W2, U$5.ILIM
- removed net NODE4_LED: LED4.A, R4.1
- removed net NODE4_RSV: J4.AUX_1@1, X4-4.S
- removed net NODE4_RSV1: J4.AUX_2@2, X4-1.S
- removed net NODE4_RSV2: J4.AUX_1@2, X4-2.S
- removed net NODE4_RSV3: J4.AUX_2@1, X4-3.S
- removed net NODE4_VOUT: J4.B+@1, J4.B+@2, R4.2, U$5.OUT@10, U$5.OUT@11, U$5.OUT@12
- removed net NODE5_ILIM: U$13.W1, U$6.ILIM
- removed net NODE5_LED: LED5.A, R5.1
- removed net NODE5_RSV1: J5.AUX_2@2, X5-1.S
- removed net NODE5_RSV2: J5.AUX_1@2, X5-2.S
- removed net NODE5_RSV3: J5.AUX_2@1, X5-3.S
- removed net NODE5_RSV4: J5.AUX_1@1, X5-4.S
- removed net NODE5_VOUT: J5.B+@1, J5.B+@2, R5.2, U$6.OUT@10, U$6.OUT@11, U$6.OUT@12
- removed net NODE6_ILIM: U$13.W2, U$7.ILIM
- removed net NODE6_LED: LED6.A, R6.1
- removed net NODE6_RSV2: J6.AUX_1@2, X6-2.S
- removed net NODE6_RSV21: J6.AUX_2@2, X6-1.S
- removed net NODE6_RSV3: J6.AUX_2@1, X6-3.S
- removed net NODE6_RSV4: J6.AUX_1@1, X6-4.S
- removed net NODE6_VOUT: J6.B+@1, J6.B+@2, R6.2, U$7.OUT@10, U$7.OUT@11, U$7.OUT@12
- removed net NODE7_ILIM: U$12.W1, U$8.ILIM
- removed net NODE7_LED: LED7.A, R7.1
- removed net NODE7_RSV1: J7.AUX_2@2, X7-1.S
- removed net NODE7_RSV2: J7.AUX_1@2, X7-2.S
- removed net NODE7_RSV3: J7.AUX_2@1, X7-3.S
- removed net NODE7_RSV4: J7.AUX_1@1, X7-4.S
- removed net NODE7_VOUT: J7.B+@1, J7.B+@2, R7.2, U$8.OUT@10, U$8.OUT@11, U$8.OUT@12
- removed net NODE8_ILIM: U$12.W2, U$9.ILIM
- removed net NODE8_LED: LED8.A, R8.1
- removed net NODE8_RSV1: J8.AUX_2@2, X8-1.S
- removed net NODE8_RSV2: J8.AUX_1@2, X8-2.S
- removed net NODE8_RSV3: J8.AUX_2@1, X8-3.S
- removed net NODE8_RSV4: J8.AUX_1@1, X8-4.S
- removed net NODE8_VOUT: J8.B+@1, J8.B+@2, R8.2, U$9.OUT@10, U$9.OUT@11, U$9.OUT@12
- removed net PD0: U$1.PD0, U$2.!FLT
- removed net PD1: U$1.PD1, U$2.!EN
- removed net PD10: U$1.PD10, U$1.PD11, U$7.!FLT
- removed net PD11: U$7.!EN
- removed net PD12: U$1.PD12, U$8.!FLT
- removed net PD13: U$1.PD13, U$8.!EN
- removed net PD14: U$1.PD14, U$9.!FLT
- removed net PD15: U$1.PD15, U$9.!EN
- removed net PD2: U$1.PD2, U$3.!FLT
- removed net PD3: U$1.PD3, U$3.!EN
- removed net PD4: U$1.PD4, U$4.!FLT
- removed net PD5: U$1.PD5, U$4.!EN
- removed net PD6: U$1.PD6, U$5.!FLT
- removed net PD7: U$1.PD7, U$5.!EN
- removed net PD8: U$1.PD8, U$6.!FLT
- removed net PD9: U$1.PD9, U$6.!EN
- removed net RMII_MDINT: U$1.PA3
- removed net RMII_REF_CLK: U$1.PA1
- removed net RMII_RXD0: U$1.PC4
- removed net RMII_RXD1: U$1.PC5
- removed net RMII_TXD0: U$1.PB12
- removed net RMII_TXD1: U$1.PB13
- removed net RMII_TX_EN: U$1.PB11
- removed net RMI_CRS_DV: U$1.PA7
- removed net SPI_MISO: U$1.PB14
- removed net SPI_MOSI: U$1.PB15
- removed net SPI_NSS: U$1.PB9
- removed net SPI_SCK: U$1.PB10
- removed net VBAT: U$2.IN@1, U$2.IN@2, U$2.IN@3, U$3.IN@1, U$3.IN@2, U$3.IN@3, U$4.IN@1, U$4.IN@2, U$4.IN@3, U$5.IN@1, U$5.IN@2, U$5.IN@3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
- new net +5V_JTAG: JTAG.19, RM5G1.1
- new net 25MHZ_REF_CLK: U$1.PB9, U$14.X1
- new net AUTOMDIX: U$1.PB2, U$14.AUTOMDIX
- new net CTS: SV1.2, U$1.PD11
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Other:
- note added: "JTAG"
- note added: "Reset"
- note added: "UART"
- moved on the sheet: C7, R11, R12, SW1

Commit message: updated mcu, eth, and connector schematics.
Parts:
- removed SW1: SW_MOMENTARY-6X3.5MM, psas:SW_MOMENTARY-6X3.5MM
- added C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C61, C62, C63, C64, C65, C66, C67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: (no value), rcl:C-EUC0402
- added C79, C80, C81, C82: 10u, rcl:C-EUC0402
- added C83, C85: .1u, rcl:C-EUC0402
- added C84: 47u, rcl:C-EUC1206
- added D1, D2: DIODE-0603, diode-0603:DIODE-0603
- added E1, E2, E3, E4, E5, E6: (no value), rcl_custom:L-BEAD-0603-B
- added LED1, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED2, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED3, LED30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: (no value), led:LEDCHIPLED_0603
- added LED37: (no value), LED_RGB_PLCC6:LED_RGB_PLCC-6
- added R1, R10, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R3, R30, R31, R32, R35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: 220, rcl:R-US_R0402
- added R42, R43, R47: 10k, rcl:R-US_R0402
- added R48: 10, rcl:R-US_R0402
- added T1: (no value), zetex:PMOSSOT23
- added T2: (no value), zetex:NMOSSOT23
- added U$2: MIC37101-2.1YM, MIC37100:MIC37101-2.1YM
- Q1: value 12.000MHz -> 25.000MHz
Connections:
- new net +5V: U$2.IN
- new net ACOK: U$1.PA12
- new net N$10: LED3.A, R3.1
- new net N$100: LED9.C, U$14.LED[3][3]
- new net N$101: LED13.C, U$14.LED[4][3]
- new net N$102: LED17.C, U$14.LED[5][3]
- new net N$103: LED21.C, U$14.LED[6][3]
- new net N$104: LED25.C, U$14.LED[7][3]
- new net N$105: LED29.C, U$14.LED[8][3]
- new net N$106: LED33.C, U$14.LED[9][3]
- new net N$107: C83.1, D1.ANODE, D2.ANODE, R47.2, U$14.!RST
- new net N$108: C16.2, C17.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C61.2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
- new net N$109: C73.2, C74.2, C75.2, C76.2, C82.2, E2.1, U$14.VDD, U$14.VDD1, U$14.VDD2, U$14.VDD3
- new net N$11: LED4.C, U$14.LED[1][0]
- new net N$110: C72.2, C81.2, E6.1, U$14.VDD_PLL
- new net N$111: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, E4.2, U$1.VDD1, U$1.VDD2, U$1.VDD3, U$1.VDD4, U$1.VDD5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
- new net N$112: E3.1
- new net N$113: E5.2, U$1.VDDA
- new net N$114: LED38.A, R48.1
- new net N$14: LED4.A, R4.1
- new net N$15: R43.2, U$1.PD14, U$2.EN
- new net N$16: R42.2, T1.G, T2.D
- new net N$17: LED5.A, R5.1
- new net N$18: LED6.C, U$14.LED[2][2]
- new net N$19: LED6.A, R6.1
- new net N$20: LED7.C, U$14.LED[2][1]
- new net N$21: LED7.A, R7.1
- new net N$22: LED8.C, U$14.LED[2][0]
- new net N$27: LED8.A, R8.1
- new net N$28: C12.1, R43.1, T2.G
- new net N$3: LED1.C, U$14.LED[1][3]
- new net N$41: LED5.C, U$14.LED[2][3]
- new net N$43: LED9.A, R9.1
- new net N$44: LED10.C, U$14.LED[3][2]
- new net N$45: LED10.A, R10.1
- new net N$46: LED11.C, U$14.LED[3][1]
- new net N$47: LED11.A, R14.1
- new net N$48: LED12.C, U$14.LED[3][0]
- new net N$49: LED12.A, R15.1
- new net N$50: LED37R.K, U$1.PD13
- new net N$51: LED13.A, R16.1
- new net N$52: LED14.C, U$14.LED[4][2]
- new net N$53: LED14.A, R17.1
- new net N$54: LED15.C, U$14.LED[4][1]
- new net N$55: LED15.A, R18.1
- new net N$56: LED16.C, U$14.LED[4][0]
- new net N$57: LED16.A, R19.1
- new net N$58: U$1.PD15, U$2.FLG
- new net N$59: LED17.A, R20.1
- new net N$6: LED1.A, R1.1
- new net N$60: LED18.C, U$14.LED[5][2]
- new net N$61: LED18.A, R21.1
- new net N$62: LED19.C, U$14.LED[5][1]
- new net N$63: LED19.A, R22.1
- new net N$64: LED20.C, U$14.LED[5][0]
- new net N$65: LED20.A, R23.1
- new net N$66: LED37G.K, U$1.PD10
- new net N$67: LED21.A, R24.1
- new net N$68: LED22.C, U$14.LED[6][2]
- new net N$69: LED22.A, R25.1
- new net N$7: LED2.C, U$14.LED[1][2]
- new net N$70: LED23.C, U$14.LED[6][1]
- new net N$71: LED23.A, R26.1
- new net N$72: LED24.C, U$14.LED[6][0]
- new net N$73: LED24.A, R27.1
- new net N$74: LED37B.K, U$1.PD7
- new net N$75: LED25.A, R28.1
- new net N$76: LED26.C, U$14.LED[7][2]
- new net N$77: LED26.A, R29.1
- new net N$78: LED27.C, U$14.LED[7][1]
- new net N$79: LED27.A, R30.1
- new net N$8: LED2.A, R2.1
- new net N$80: LED28.C, U$14.LED[7][0]
- new net N$81: LED28.A, R31.1
- new net N$82: LED37R.A, R46.1
- new net N$83: LED29.A, R32.1
- new net N$84: LED30.C, U$14.LED[8][2]
- new net N$86: LED30.A, R35.1
- new net N$87: LED31.C, U$14.LED[8][1]
- new net N$88: LED31.A, R36.1
- new net N$89: LED32.C, U$14.LED[8][0]
- new net N$9: LED3.C, U$14.LED[1][1]
- new net N$90: LED32.A, R37.1
- new net N$91: LED37G.A, R45.1
- new net N$92: LED33.A, R38.1
- new net N$93: LED34.C, U$14.LED[9][2]
- new net N$94: LED34.A, R39.1
- new net N$95: LED35.C, U$14.LED[9][1]
- new net N$96: LED35.A, R40.1
- new net N$97: LED36.C, U$14.LED[9][0]
- new net N$98: LED36.A, R41.1
- new net N$99: LED37B.A, R44.1
- new net ROCKET_RDY: U$1.PA11
- new net SYNC: U$1.PA8
- new net VDD: C84.1, C85.1, D2.CATHODE, E1.2, E2.2, E6.2, R47.1, R48.2, U$2.OUT
- new net VDD_IO: C13.2, C14.2, C15.2, C77.2, E3.2, T1.D, U$14.VDD-IO, U$14.VDD-IO1, U$14.VDD-IO2
- net +3V3: now also E4.1, E5.1, R1.2, R10.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R2.2, R20.2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; no longer C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, U$1.VDD1, U$1.VDD2, U$1.VDD3, U$1.VDD4, U$1.VDD5, U$1.VDD6
- net 25MHZ_REF_CLK: now also U$1.PC9; no longer U$1.PB9
- net CTS: now also SV1.6; no longer SV1.2
- net GND: now also C12.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1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; no longer SW1.1
- net MIIS0: now also U$1.PA10; no longer U$1.PA8
- net N$24: now also U$14.RXM[2]
- net N$26: now also U$14.TXP[2]
- net N$29: now also U$14.RXM[3]
- net N$30: now also U$14.TXP[3]
- net N$31: now also U$14.RXM[4]
- net N$32: now also U$14.TXP[4]
- net N$33: now also U$14.RXM[5]
- net N$34: now also U$14.TXP[5]
- net N$35: now also U$14.RXM[6]
- net N$36: now also U$14.TXP[6]
- net N$37: now also U$14.RXM[7]
- net N$38: now also U$14.TXP[7]
- net N$39: now also U$14.RXM[8]
- net N$40: now also U$14.TXP[8]
- net NODE1_RXP: now also U$14.RXP[2], U$14.RXP[3], U$14.RXP[4], U$14.RXP[5], U$14.RXP[6], U$14.RXP[7], U$14.RXP[8]
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Other:
- moved on the sheet: C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40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

Commit message: updated schematics
Parts:
- added C86: (no value), rcl:C-EUC0402
Connections:
- net GND: now also C86.2, U$1.VSSA
- net N$113: now also C86.1
Changed lines of the file:
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@@
 <part name="LED38" library="led" deviceset="LED" device="CHIPLED_0603"/>
 <part name="R48" library="rcl" deviceset="R-US_" device="R0402" value="10"/>
+<part name="C86" library="rcl" deviceset="C-EU" device="C0402"/>
+<part name="GND17" library="supply1" deviceset="GND" device=""/>
 </parts>
 <sheets>
@@
 <instance part="LED38" gate="G$1" x="256.54" y="187.96"/>
 <instance part="R48" gate="G$1" x="256.54" y="195.58" rot="R90"/>
+<instance part="C86" gate="G$1" x="99.06" y="314.96"/>
+<instance part="GND17" gate="1" x="99.06" y="297.18"/>
 </instances>
 <busses>
@@
 <wire x1="256.54" y1="182.88" x2="266.7" y2="182.88" width="0.1524" layer="91"/>
 </segment>
+<segment>
+<pinref part="GND17" gate="1" pin="GND"/>
+<pinref part="C86" gate="G$1" pin="2"/>
+<wire x1="99.06" y1="299.72" x2="99.06" y2="309.88" width="0.1524" layer="91"/>
+<pinref part="U$1" gate="G$1" pin="VSSA"/>
+<wire x1="101.6" y1="327.66" x2="101.6" y2="299.72" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="299.72" x2="99.06" y2="299.72" width="0.1524" layer="91"/>
+<junction x="99.06" y="299.72"/>
+</segment>
 </net>
 <net name="+3V3" class="0">
@@
 <pinref part="U$1" gate="G$1" pin="VDDA"/>
 <wire x1="99.06" y1="325.12" x2="99.06" y2="327.66" width="0.1524" layer="91"/>
+<pinref part="C86" gate="G$1" pin="1"/>
+<wire x1="99.06" y1="317.5" x2="99.06" y2="325.12" width="0.1524" layer="91"/>
+<junction x="99.06" y="325.12"/>
 </segment>
 </net>

Commit message: initial rough placement
Parts:
- added C100, C101, C102, C87, C88, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99: (no value), rcl:C-EUC0402K
- added C103, C104: 2.2u, rcl:C-EUC0402
- added C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C116, C117, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128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: (no value), rcl:C-EUC0402
- added D3: BAT54, diode:BAT54
- added D4: BAT54C, diode:BAT54C
- added J1, J2, J3, J4, J5, J6, J7, J8: ROCKETBUS, rocketbus:ROCKETBUS
- added JP1, JP2, JP3: (no value), pinhead:PINHD-1X3
- added JP4, JP5: (no value), pinhead:PINHD-1X2
- added L2: (no value), rcl_custom:L-US0603-B
- added LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46: (no value), led:LEDSML0603
- added R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72: (no value), rcl:R-US_R0402
- added R73: 154k, rcl:R-US_R0402
- added R74: 49.9k, rcl:R-US_R0402
- added R75, R76, R88, R89, R90, R92, R94, R95: (no value), rcl_custom:R-US_0603-B
- added R77: 100k, rcl_custom:R-US_0603-B
- added R78: 316k, rcl_custom:R-US_0603-B
- added R79, R91, R93, R96: 12.1k, rcl_custom:R-US_0603-B
- added R80: 10k, rcl_custom:R-US_0603-B
- added R81, R82: 4.02k, rcl_custom:R-US_0603-B
- added R83: 66.5k, rcl_custom:R-US_0603-B
- added R84, R86, R87: 430k, rcl_custom:R-US_0603-B
- added R85, R97, R98: 10, rcl_custom:R-US_0603-B
- added U$10, U$3, U$4, U$5, U$6, U$7, U$8, U$9: TPS2420QFN-16, RNH_TPS2420:TPS2420QFN-16
- added U$11: LTM8023, RNH_LTM8023:LTM8023
- added U$12: BQ24725QFN-20, RNH_BQ24725:BQ24725QFN-20
- added U$13: BSS138W-7-F, RNH_BSS138W-7-F:BSS138W-7-F
- added U$15, U$16, U$17: FDS6680ASOIC-8, RNH_FDS6680A:FDS6680ASOIC-8
- added U$18, U$19: SIS412DNSOP-8, RNH_SIS412DN:SIS412DNSOP-8
- added X1, X2, X3, X4, X5, X6, X7, X8: 87758-0416, con-molex:87758-0416
Connections:
- new net +18V: C103.1, C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, U$10.IN@1, U$10.IN@2, U$10.IN@3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
- new net 3V3: R97.1, R98.1
- new net 3V3@1: R78.2
- new net ACDET: C108.1, R83.2, R84.1, U$12.ACDET
- new net ACDRV: R81.1, U$12.ACDRV
- new net BAT: JP4.2
- new net BAT@1: C105.1, C112.2, C115.1, C128.1, C129.2, JP3.2, R76.1, R90.1, R96.1, U$17.S@1, U$17.S@3
- new net BATDRV: C129.1, R75.1, R96.2, U$17.G
- new net CMSRC: R82.1, U$12.CMSRC
- new net ILIM: C106.1, R77.2, R78.1, U$12.ILIM
- new net IOUT: C107.1, U$12.IOUT
- new net N$115: U$11.AUX, U$11.BIAS
- new net N$116: R73.2, U$11.ADJ
- new net N$117: R74.2, U$11.RT
- new net N$118: D4.CC, R85.2
- new net N$119: D4.A1, JP4.1
- new net N$120: C109.2, R86.2, R87.2
- new net N$121: R75.2, U$12.BATDRV
- new net N$122: C89.2, U$3.GND@5
- new net N$123: C88.2, U$4.GND@5
- new net N$124: C87.2, U$5.GND@5
- new net N$125: C90.2, U$6.GND@5
- new net N$126: C91.2, U$7.GND@5
- new net N$127: C92.2, U$8.GND@5
- new net N$128: C93.2, U$9.GND@5
- new net N$129: C94.2, U$10.GND@5
- new net N$130: R51.2, U$3.IMAX
- new net N$131: LED39.A, R50.1
- new net N$132: C95.1, U$3.CT
- new net N$133: LED40.A, R53.1
- new net N$134: LED41.A, R55.1
- new net N$135: LED42.A, R57.1
- new net N$136: LED43.A, R59.1
- new net N$137: LED44.A, R61.1
- new net N$138: LED45.A, R63.1
- new net N$139: LED46.A, R65.1
- new net N$140: C96.1, U$4.CT
- new net N$141: C97.1, U$5.CT
- new net N$142: C98.1, U$7.CT
- new net N$143: C99.1, U$6.CT
- new net N$144: C100.1, U$8.CT
- new net N$145: C101.1, U$9.CT
- new net N$146: C102.1, U$10.CT
- new net N$147: U$5.IFLT
- new net N$148: R67.2
- new net N$149: R68.2
- new net N$150: R69.2
- new net N$151: R70.2
- new net N$152: R71.2
- new net N$153: R72.2
- new net N$154: U$7.IFLT
- new net N$155: U$9.IFLT
- new net N$156: R66.2, U$4.IMAX
- new net N$157: U$4.IFLT
- new net N$158: U$6.IFLT
- new net N$159: U$8.IFLT
- new net N$160: R76.2, U$12.SRN
- new net N$161: R88.2, U$12.SRP
- new net N$162: C111.1, C112.1, L2.2, R88.1, R90.2
- new net N$163: R89.2, U$12.BTST
- new net N$164: C114.1, D3.C, R89.1
- new net N$165: C116.1, C117.1, C120.2, R92.2, U$12.ACP
- new net N$166: C118.1, U$12.LODRV, U$19.G
- new net N$167: C119.1, U$12.HIDRV, U$18.G
- new net N$168: C120.1, C121.1, R91.1, U$12.ACN
- new net N$169: C125.1, R82.2, R93.2, R95.1, U$13.S, U$15.S@1, U$15.S@2, U$15.S@3, U$16.S@1, U$16.S@2, U$16.S@3
- new net N$170: R94.1, R95.2, U$13.G\
- new net N$171: C110.2, C125.2, R81.2, R93.1, U$13.D, U$15.G, U$16.G
- new net N$172: C114.2, C119.2, L2.1, U$12.PHASE
- new net NODE1_ILIM: U$3.IFLT
- new net NODE1_RSV1: J1.AUX_2@2, X1-1.S
- new net NODE1_RSV2: J1.AUX_1@2, X1-2.S
- new net NODE1_RSV3: J1.AUX_2@1, X1-3.S
- new net NODE1_RSV4: J1.AUX_1@1, X1-4.S
- new net NODE1_VOUT: J1.B+@1, J1.B+@2, U$3.OUT@10, U$3.OUT@11, U$3.OUT@12
- new net NODE2_RSV1: J2.AUX_2@2, X2-1.S
- new net NODE2_RSV2: J2.AUX_1@2, X2-2.S
- new net NODE2_RSV3: J2.AUX_2@1, X2-3.S
- new net NODE2_RSV4: J2.AUX_1@1, X2-4.S
- new net NODE2_VOUT: J2.B+@1, J2.B+@2, U$4.OUT@10, U$4.OUT@11, U$4.OUT@12
- new net NODE3_RSV1: J3.AUX_2@2, X3-1.S
- new net NODE3_RSV2: J3.AUX_1@2, X3-2.S
- new net NODE3_RSV3: J3.AUX_2@1, X3-3.S
- new net NODE3_RSV4: J3.AUX_1@1, X3-4.S
- new net NODE3_VOUT: J3.B+@1, J3.B+@2, U$5.OUT@10, U$5.OUT@11, U$5.OUT@12
- new net NODE4_RSV: J4.AUX_1@1, X4-4.S
- new net NODE4_RSV1: J4.AUX_2@2, X4-1.S
- new net NODE4_RSV2: J4.AUX_1@2, X4-2.S
- new net NODE4_RSV3: J4.AUX_2@1, X4-3.S
- new net NODE4_VOUT: J4.B+@1, J4.B+@2, U$6.OUT@10, U$6.OUT@11, U$6.OUT@12
- new net NODE5_RSV1: J5.AUX_2@2, X5-1.S
- new net NODE5_RSV2: J5.AUX_1@2, X5-2.S
- new net NODE5_RSV3: J5.AUX_2@1, X5-3.S
- new net NODE5_RSV4: J5.AUX_1@1, X5-4.S
- new net NODE5_VOUT: J5.B+@1, J5.B+@2, U$7.OUT@10, U$7.OUT@11, U$7.OUT@12
- new net NODE6_RSV2: J6.AUX_1@2, X6-2.S
- new net NODE6_RSV21: J6.AUX_2@2, X6-1.S
- new net NODE6_RSV3: J6.AUX_2@1, X6-3.S
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Other:
- note added: "PSAS Rocketnet Hub Battery Charger Schematic"
- note added: "Schematic is missing: - Chassis ground - Net names - TP1? - Test points - Component values"
- note added: "v1"
